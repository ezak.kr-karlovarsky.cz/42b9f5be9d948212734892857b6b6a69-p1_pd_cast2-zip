Properties of the parts of a building model (IFC4)

# File
Description: no view
File name: 604-SOKOLOV_jama_vykopy_teren_3D_b.ifc
Time: 2023-03-16T07:43:10
Author: Sglunda Jakub
Organization: TECHNICO Opava s.r.o., Hradecká 51
Written by: EDMsix Version 2.0.209.92 Dec 12 2020
Made in: Allplan 2022.1 04.08.2022 - 12:20:12

# IfcSite, 1. Situace
RefLatitude: 48, 0, 0, 0; RefLongitude: 0, 0, 0, 0

# IfcElementAssembly
In: Terén
AllplanAttributes - Allright_Stavebni_dil_ID: 0191Oso1096328686; Jednotka: m3; Název_objektu: Osový rastr
