Properties of the parts of a building model (IFC2X3), part 1 of 5

# File
Description: ViewDefinition [CoordinationView, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 8df2ad49-971f-4946-8c6c-eaa4ba38bb5f, NumberOfSaves: 40], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
Time: 2023-03-22T08:54:12+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.20.21 - Exporter 23.2.3.0 - Alternate UI 23.2.3.0

# IfcSite, Mediplyny
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
NEMSOK - ID: 1238; Kategorie: Informace o projektu

# IfcBuilding, Pavilon C
Pset_BuildingCommon - NumberOfStoreys: 3
NEMSOK - ID: 1238; Kategorie: Informace o projektu

# IfcBuildingStorey: Podlaží:CS_Podlaží - nulová úroveň (3)
In: Pavilon C
NEMSOK - Výpočtová výška: 0 mm; Konstrukce: no; Podlaží budovy: yes; Id typu: 2777; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: CS_Podlaží - nulová úroveň; Typ: CS_Podlaží - nulová úroveň; Základní výška: Bod zaměření; Barva: 0; Symbol: CS_Podlaží - označení šipka - nulová úroveň; Symbol na konci 1 – výchozí: yes; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: Tečkovaná 1.5mm; Název typu: CS_Podlaží - nulová úroveň; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) = Výška (mm) | ID
Půdorys 1.PP | Podlaží 1.PP | -3300 | 432836
Půdorys 1.NP | Podlaží 1.NP | 0 | 7245
Půdorys 2.NP | Podlaží 2.NP | 4000 | 7246

# IfcBuildingElementProxy: M-G BHU 1-B (l=1650, 2xMG,4x230) R21:M-G BHU 1-B (l=1650, 2xMG,4x230) R21 (9)
In: Půdorys 1.NP
Type - Material: Měď, Mosaz, Plast, žlutý, Plast, bílý, Plast, černý, Kov, práškový nástřik, bílý, Plast, průhledný, Plast, zelený, Nerezová ocel, kartáčovaná
Type - NEMSOK - Výchozí výška: 0 mm; Klasifikace: Žádné; Tlakový stupeň: PN; Číslo OmniClass: 23.75.00.00; Nadpis OmniClass: Climate Control (HVAC); Název typu: M-G BHU 1-B (l=1650, 2xMG,4x230) R21; Označení typu: MT; Kategorie: AllplanAttributes zařízení; Název rodiny: M-G BHU 1-B (l=1650, 2xMG,4x230) R21
Pset_BuildingElementProxyCommon - Reference: M-G BHU 1-B (l=1650, 2xMG,4x230) R21; sets with these values: 2
NEMSOK - CS_SCHEDULETYPEID: 472942; Délka: 1650 mm; Jmenovitá velikost vstupu: 10 mm - 3x (O2,Air,Vac); Podlaží: Podlaží 1.NP; Šířka: 65 mm; Výška: 304 mm; Hostitel: Podlaží : Podlaží 1.NP; Odsazení od hostitele: 1350 mm; Výška od podlaží: 1350 mm; Fáze vytvoření: Nová konstrukce; Klasifikace systému: Ostatní; Objem: 0.0324265 m3; Plocha: 0.939256 m2; Komentáře: Cu; Id typu: 472942; Rodina: M-G BHU 1-B (l=1650, 2xMG,4x230) R21; Rodina a typ: M-G BHU 1-B (l=1650, 2xMG,4x230) R21: M-G BHU 1-B (l=1650, 2xMG,4x230) R21; Typ: M-G BHU 1-B (l=1650, 2xMG,4x230) R21
Name (M-G BHU 1-B (l=1650, 2xMG,4x230) R21:M-G BHU 1-B (l=1650, 2xMG,4x230) R21:...) | CS_SCHEDULEID = ID | Číslo místnosti | Kód prvku | Jmenovitý tlak | Označení | Group
472958 | 472958 | 1.16 | MT.03.472958 | Vakuum 4,Vzduch (4bar) 2,O2 (4bar) 3 | 46 | O2 (4bar) 3; Vzduch (4bar) 2; Vakuum 4
474163 | 474163 | 1.16 | MT.03.474163 | O2 (4bar) 3,Vzduch (4bar) 2,Vakuum 4,Vzduch (4bar) 2,O2 (4bar) 3 | 48 | O2 (4bar) 3; Vzduch (4bar) 2; Vakuum 4
474181 | 474181 | 1.15 | MT.03.474181 | Vakuum 4,Vzduch (4bar) 2,O2 (4bar) 3 | 49 | O2 (4bar) 3; Vzduch (4bar) 2; Vakuum 4
474318 | 474318 | 1.14 | MT.03.474318 | Vakuum 4,Vzduch (4bar) 2,O2 (4bar) 3 | 50 | O2 (4bar) 3; Vzduch (4bar) 2; Vakuum 4
474332 | 474332 | 1.13 | MT.03.474332 | Vakuum 4,Vzduch (4bar) 2,O2 (4bar) 3 | 51 | O2 (4bar) 3; Vzduch (4bar) 2; Vakuum 4
474346 | 474346 | 1.12 | MT.03.474346 | O2 (4bar) 4 (1),Vzduch (4bar) 4,Vakuum 2 | 52 | O2 (4bar) 4 (1); Vzduch (4bar) 4; Vakuum 2
474360 | 474360 | 1.11 | MT.03.474360 | O2 (4bar) 4 (1),Vzduch (4bar) 4,Vakuum 2 | 53 | O2 (4bar) 4 (1); Vzduch (4bar) 4; Vakuum 2
474374 | 474374 | 1.10 | MT.03.474374 | O2 (4bar) 4 (1),Vzduch (4bar) 4,Vakuum 2 | 54 | O2 (4bar) 4 (1); Vzduch (4bar) 4; Vakuum 2
474417 | 474417 | 1.10 | MT.03.474417 | Vakuum 2,Vzduch (4bar) 4,O2 (4bar) 4 (1) | 55 | O2 (4bar) 4 (1); Vzduch (4bar) 4; Vakuum 2

# IfcBuildingElementProxy: M-G VB 1g (1x18) R22:M-G VB 1g (1x18) R22, M-G VB 1g (1x18) R22:M-G VB 1g (1x18) R22:442740
In: Půdorys 1.PP
Type - Material: Plast, průhledný, Plast, zelený, Plast, šedý, <Unnamed>, Měď, Plast, černý, Kov, práškový nástřik, bílý, Plast, oranžový
Type - NEMSOK - Výchozí výška: 0 mm; Klasifikace: Žádné; Tlakový stupeň: PN; Číslo OmniClass: 23.75.00.00; Nadpis OmniClass: Climate Control (HVAC); Název typu: M-G VB 1g (1x18) R22; Označení typu: MS; Kategorie: AllplanAttributes zařízení; Název rodiny: M-G VB 1g (1x18) R22
Pset_BuildingElementProxyCommon - Reference: M-G VB 1g (1x18) R22; sets with these values: 2
NEMSOK - CS_SCHEDULEID: 442740; CS_SCHEDULETYPEID: 437380; ID: 442740; Číslo místnosti: -1.34; Délka: 100 mm; Jmenovitá velikost vstupu: 15 mm - 1x (O2); Kód prvku: MS.02.442740; Podlaží: Podlaží 1.NP; Šířka: 356 mm; Výška: 456 mm; Hostitel: Podlaží : Podlaží 1.PP; Odsazení od hostitele: 1350 mm; Výška od podlaží: 1350 mm; Fáze vytvoření: Nová konstrukce; Klasifikace systému: Ostatní; Jmenovitý tlak: Vakuum 1,O2 (4bar) 2; Objem: 0.0128317 m3; Plocha: 0.4666 m2; Komentáře: Cu; Označení: 15; Id typu: 437380; Rodina: M-G VB 1g (1x18) R22; Rodina a typ: M-G VB 1g (1x18) R22: M-G VB 1g (1x18) R22; Typ: M-G VB 1g (1x18) R22
Group: Vakuum 1; O2 (4bar) 2; O2 (4bar) 9

# IfcBuildingElementProxy: M-G VB 3g (3x18) R22:M-G VB 3g (3x18) R22 (2)
In: Půdorys 1.NP
Type - Material: Měď, Plast, průhledný, Plast, zelený, Plast, šedý, <Unnamed>, Plast, černý, Kov, práškový nástřik, bílý, Plast, oranžový
Type - NEMSOK - Výchozí výška: 0 mm; Klasifikace: Žádné; Tlakový stupeň: PN; Číslo OmniClass: 23.75.00.00; Nadpis OmniClass: Climate Control (HVAC); Název typu: M-G VB 3g (3x18) R22; Označení typu: MS; Kategorie: AllplanAttributes zařízení; Název rodiny: M-G VB 3g (3x18) R22
Pset_BuildingElementProxyCommon - Reference: M-G VB 3g (3x18) R22; sets with these values: 2
NEMSOK - CS_SCHEDULETYPEID: 441226; Číslo místnosti: 1.30; Délka: 100 mm; Jmenovitá velikost vstupu: 15 mm - 3x (O2,Air,Vac); Podlaží: Podlaží 1.NP; Šířka: 356 mm; Výška: 456 mm; Hostitel: Podlaží : Podlaží 1.NP; Odsazení od hostitele: 1250 mm; Výška od podlaží: 1250 mm; Fáze vytvoření: Nová konstrukce; Klasifikace systému: Ostatní; Objem: 0.0130415 m3; Plocha: 0.487956 m2; Komentáře: Cu; Id typu: 441226; Rodina: M-G VB 3g (3x18) R22; Rodina a typ: M-G VB 3g (3x18) R22: M-G VB 3g (3x18) R22; Typ: M-G VB 3g (3x18) R22
Name (M-G VB 3g (3x18) R22:M-G VB 3g (3x18) R22:...) | CS_SCHEDULEID = ID | Kód prvku | Jmenovitý tlak | Označení | Group
444017 | 444017 | MS.03.444017 | O2 (4bar) 3,O2 (4bar) 1,Vzduch (4bar) 2,Vzduch (4bar) 3,Vakuum 4,Vakuum 1 | 27 | O2 (4bar) 1; Vzduch (4bar) 3; Vakuum 1; O2 (4bar) 3; Vzduch (4bar) 2; Vakuum 4
444114 | 444114 | MS.03.444114 | O2 (4bar) 4 (1),O2 (4bar) 1,Vzduch (4bar) 4,Vzduch (4bar) 3,Vakuum 2,Vakuum 1 | 28 | O2 (4bar) 1; Vzduch (4bar) 3; Vakuum 1; O2 (4bar) 4 (1); Vzduch (4bar) 4; Vakuum 2

# IfcBuildingElementProxy: M-G clinic alarm R21:M-G clinic alarm R21, M-G clinic alarm R21:M-G clinic alarm R21:449443
In: Půdorys 1.NP
Type - Material: Kov, práškový nástřik, bílý, Plast, průhledný, Plast, černý, Plast, bílý
Type - NEMSOK - Výchozí výška: 0 mm; Klasifikace: Žádné; Tlakový stupeň: PN; Číslo OmniClass: 23.75.00.00; Nadpis OmniClass: Climate Control (HVAC); Název typu: M-G clinic alarm R21; Označení typu: MS; Kategorie: AllplanAttributes zařízení; Název rodiny: M-G clinic alarm R21
Pset_BuildingElementProxyCommon - Reference: M-G clinic alarm R21; sets with these values: 2
Pset_ProvisionForVoid - Width: 168 mm; Height: 2 mm; Depth: 2 mm
NEMSOK - CS_SCHEDULEID: 449443; CS_SCHEDULETYPEID: 449424; ID: 449443; Číslo místnosti: 1.09; Délka: 190 mm; Kód prvku: MS.03.449443; Podlaží: Podlaží 1.NP; Šířka: 74 mm; Výška: 114 mm; Hostitel: Podlaží : Podlaží 1.NP; Odsazení od hostitele: 1600 mm; Přesunout s blízkými prvky: no; Výška od podlaží: 1600 mm; Fáze vytvoření: Nová konstrukce; Objem: 0.00126709 m3; Plocha: 0.0986661 m2; Označení: 38; Id typu: 449424; Rodina: M-G clinic alarm R21; Rodina a typ: M-G clinic alarm R21: M-G clinic alarm R21; Typ: M-G clinic alarm R21

# IfcBuildingElementProxy: M-G operational alarm assembly:M-G operational alarm assembly (6)
Type - Material: Laminát, červený, matný
Type - NEMSOK - Výchozí výška: 0 mm; Klasifikace: Žádné; Tlakový stupeň: PN; Číslo OmniClass: 23.75.00.00; Nadpis OmniClass: Climate Control (HVAC); Název typu: M-G operational alarm assembly; Označení typu: MS; Kategorie: AllplanAttributes zařízení; BOS_0_Material: Steel 969A062D; BOS_0_Visibility_Bool: yes; BOS_1_Material: Steel 969A062D; BOS_1_Visibility_Bool: yes; BOS_10_Material: Steel 969A062D; BOS_10_Visibility_Bool: yes; BOS_11_Material: Steel 969A062D; BOS_11_Visibility_Bool: yes; BOS_2_Material: Steel 969A062D; BOS_2_Visibility_Bool: yes; BOS_3_Material: Steel 969A062D; BOS_3_Visibility_Bool: yes; BOS_4_Material: Steel 969A062D; BOS_4_Visibility_Bool: yes; BOS_5_Material: Steel 969A062D; BOS_5_Visibility_Bool: yes; BOS_6_Material: Steel 969A062D; BOS_6_Visibility_Bool: yes; BOS_7_Material: Steel 969A062D; BOS_7_Visibility_Bool: yes; BOS_8_Material: Steel 969A062D; BOS_8_Visibility_Bool: yes; BOS_9_Material: Steel 969A062D; BOS_9_Visibility_Bool: yes; Název rodiny: M-G operational alarm assembly
Material: Laminát, červený, matný, Mosaz, Plast, průhledný, Plast černý, Steel 969A062D
Pset_BuildingElementProxyCommon - Reference: M-G operational alarm assembly; sets with these values: 2
NEMSOK - CS_SCHEDULETYPEID: 456073; Číslo místnosti: Stoupačka; Podlaží: Podlaží 1.NP; Fáze vytvoření: Nová konstrukce; Klasifikace systému: Ostatní; Jmenovitý tlak: 4 bar; Objem: 0.000117248 m3; Plocha: 0.0104785 m2; Komentáře: Cu; Id typu: 456073; Rodina: M-G operational alarm assembly; Rodina a typ: M-G operational alarm assembly: M-G operational alarm assembly; Typ: M-G operational alarm assembly
Name (M-G operational alarm assembly:M-G operational alarm assembly:...) | In | CS_SCHEDULEID = ID | Jmenovitá velikost vstupu | Kód prvku | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Označení | Group
456877 | Půdorys 1.NP | 456877 | 10 mm - 1x (Vac) | MS.03.456877 | Podlaží : Podlaží 1.NP | 1600 | 43 | Vakuum 1
457043 | Půdorys 1.NP | 457043 | 10 mm - 1x (Air) | MS.03.457043 | Podlaží : Podlaží 1.NP | 1600 | 44 | Vzduch (4bar) 3
457052 | Půdorys 1.NP | 457052 | 10 mm - 1x (O2) | MS.03.457052 | Podlaží : Podlaží 1.NP | 1600 | 45 | O2 (4bar) 1
481070 | Půdorys 1.PP | 481070 | 10 mm - 1x (O2) | MS.02.481070 | Typy trubek : Měď - EN 13348 - pájení natvrdo | 1750 | 59 | O2 (4bar) 1
481417 | Půdorys 1.PP | 481417 | 10 mm - 1x (O2) | MS.02.481417 | Podlaží : Podlaží 1.PP | 1750 | 60 | O2 (4bar) 9
485398 | Půdorys 1.PP | 485398 | 10 mm - 1x (Air) | MS.02.485398 | Podlaží : Podlaží 1.PP | 1750 | 62 | Vzduch (4bar) 3

# IfcBuildingElementProxy: M-G wall panel:M-G wall panel (9)
Type - Material: Měď, Plast, neprůhledný bílý, Mosaz, Plast, neprůhledný černý
Type - NEMSOK - Výchozí výška: 0 mm; Klasifikace: Žádné; Tlakový stupeň: PN; Číslo OmniClass: 23.75.00.00; Nadpis OmniClass: Climate Control (HVAC); Název typu: M-G wall panel; Označení typu: MT; Kategorie: AllplanAttributes zařízení; Název rodiny: M-G wall panel
Pset_BuildingElementProxyCommon - Reference: M-G wall panel; sets with these values: 2
NEMSOK - CS_SCHEDULETYPEID: 435423; Délka: 63 mm; Jmenovitá velikost vstupu: 8 mm - 1x (O2); Podlaží: Podlaží 1.NP; Výška: 75 mm; Odsazení od hostitele: 1250 mm; Výška od podlaží: 1250 mm; Fáze vytvoření: Nová konstrukce; Klasifikace systému: Ostatní; Jmenovitý tlak: 4 bar; Objem: 0.000210276 m3; Plocha: 0.0177173 m2; Komentáře: Cu; Id typu: 435423; Rodina: M-G wall panel; Rodina a typ: M-G wall panel: M-G wall panel; Typ: M-G wall panel
Name (M-G wall panel:M-G wall panel:...) | In | CS_SCHEDULEID = ID | Číslo místnosti | Kód prvku | Šířka (mm) | Hostitel | Označení | Group
443180 | Půdorys 1.PP | 443180 | -1.39 | MT.02.443180 | 75 | Podlaží : Podlaží 1.PP | 19 | O2 (4bar) 2
443375 | Půdorys 1.PP | 443375 | -1.46 | MT.02.443375 | 75 | Podlaží : Podlaží 1.PP | 20 | O2 (4bar) 2
443667 | Půdorys 1.PP | 443667 | -1.52 | MT.02.443667 | 75 | Podlaží : Podlaží 1.PP | 26 | O2 (4bar) 2
449459 | Půdorys 1.NP | 449459 | 1.02 | MT.03.449459 | 75 | Podlaží : Podlaží 1.NP | 39 | O2 (4bar) 4 (1)
449471 | Půdorys 1.NP | 449471 | 1.05 | MT.03.449471 | 75 | Podlaží : Podlaží 1.NP | 40 | O2 (4bar) 4 (1)
479074 | Půdorys 1.PP | 479074 | -1.35 | MT.02.479074 | 75 | Podlaží : Podlaží 1.PP | 56 | O2 (4bar) 2
479177 | Půdorys 1.PP | 479177 | -1.36 | MT.02.479177 | 75 | Podlaží : Podlaží 1.PP | 57 | O2 (4bar) 2
479306 | Půdorys 1.PP | 479306 | -1.37 | MT.02.479306 | 74 | Podlaží : Podlaží 1.PP | 58 | O2 (4bar) 2
482175 | Půdorys 1.PP | 482175 | -1.50 | MT.02.482175 | 75 | Podlaží : Podlaží 1.PP | 61 | O2 (4bar) 2

# IfcDistributionPort (1553)
Description: Flow
Name | FlowDirection | Group
Port_438700_0 | SOURCEANDSINK | O2 (4bar) 1
Port_442249_2 | SOURCEANDSINK | O2 (4bar) 1
Port_438700_1 | SOURCEANDSINK | O2 (4bar) 1
Port_442261_2 | SOURCEANDSINK | O2 (4bar) 1
Port_438741_0 | SOURCEANDSINK | O2 (4bar) 1
Port_456789_1 | SOURCEANDSINK | O2 (4bar) 1
Port_438741_1 | SOURCEANDSINK | O2 (4bar) 1
Port_442249_1 | SOURCEANDSINK | O2 (4bar) 1
Port_438784_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_442440_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_438784_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_442452_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_438824_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_456743_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_438824_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_442440_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_438835_0 | SOURCEANDSINK | Vakuum 1
Port_442353_2 | SOURCEANDSINK | Vakuum 1
Port_438835_1 | SOURCEANDSINK | Vakuum 1
Port_442365_2 | SOURCEANDSINK | Vakuum 1
Port_438868_0 | SOURCEANDSINK | Vakuum 1
Port_456691_1 | SOURCEANDSINK | Vakuum 1
Port_438868_1 | SOURCEANDSINK | Vakuum 1
Port_442353_1 | SOURCEANDSINK | Vakuum 1
Port_438973_0 | SOURCEANDSINK | Vakuum 1
Port_438992_2 | SOURCEANDSINK | Vakuum 1
Port_438973_1 | SOURCEANDSINK | Vakuum 1
Port_480223_1 | SOURCEANDSINK | Vakuum 1
Port_438992_1 | SOURCEANDSINK | Vakuum 1
Port_457019_0 | SOURCEANDSINK | Vakuum 1
Port_439028_0 | SOURCEANDSINK | Vakuum 1
Port_487352_2 | SOURCEANDSINK | Vakuum 1
Port_439028_1 | SOURCEANDSINK | Vakuum 1
Port_480223_2 | SOURCEANDSINK | Vakuum 1
Port_439047_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_439055_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_439047_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_480227_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_439055_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_457094_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_439060_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_480225_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_439060_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_480227_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_439081_0 | SOURCEANDSINK | O2 (4bar) 1
Port_439089_2 | SOURCEANDSINK | O2 (4bar) 1
Port_439081_1 | SOURCEANDSINK | O2 (4bar) 1
Port_480231_1 | SOURCEANDSINK | O2 (4bar) 1
Port_439089_1 | SOURCEANDSINK | O2 (4bar) 1
Port_457141_0 | SOURCEANDSINK | O2 (4bar) 1
Port_439094_0 | SOURCEANDSINK | O2 (4bar) 1
Port_487571_2 | SOURCEANDSINK | O2 (4bar) 1
Port_439094_1 | SOURCEANDSINK | O2 (4bar) 1
Port_480231_2 | SOURCEANDSINK | O2 (4bar) 1
Port_442253_1 | SOURCEANDSINK | O2 (4bar) 1
Port_456584_0 | SOURCEANDSINK | O2 (4bar) 1
Port_442253_2 | SOURCEANDSINK | O2 (4bar) 1
Port_442254_1 | SOURCEANDSINK | O2 (4bar) 1
Port_442253_3 | SOURCEANDSINK | O2 (4bar) 1
Port_442261_1 | SOURCEANDSINK | O2 (4bar) 1
Port_442254_0 | SOURCEANDSINK | O2 (4bar) 1
Port_442357_1 | SOURCEANDSINK | Vakuum 1
Port_443976_0 | SOURCEANDSINK | Vakuum 1
Port_442357_2 | SOURCEANDSINK | Vakuum 1
Port_442358_1 | SOURCEANDSINK | Vakuum 1
Port_442357_3 | SOURCEANDSINK | Vakuum 1
Port_442365_1 | SOURCEANDSINK | Vakuum 1
Port_442358_0 | SOURCEANDSINK | Vakuum 1
Port_442431_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_442444_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_442431_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492904_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_442444_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_442445_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_442444_3 | SOURCEANDSINK | Vzduch (4bar) 3
Port_442452_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_442445_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_442620_0 | SOURCEANDSINK | O2 (4bar) 1
Port_492862_2 | SOURCEANDSINK | O2 (4bar) 1
Port_442620_1 | SOURCEANDSINK | O2 (4bar) 1
Port_492885_1 | SOURCEANDSINK | O2 (4bar) 1
Port_442632_0 | SOURCEANDSINK | Vakuum 1
Port_521674_2 | SOURCEANDSINK | Vakuum 1
Port_442632_1 | SOURCEANDSINK | Vakuum 1
Port_476921_2 | SOURCEANDSINK | Vakuum 1
InPort_442740_1 | SINK | Vakuum 1
OutPort_442794_0 | SOURCE | Vakuum 1
InPort_442827_0 | SINK | O2 (4bar) 2
OutPort_442740_2 | SOURCE | O2 (4bar) 2
Port_442784_0 | SOURCEANDSINK | O2 (4bar) 9
Port_476469_2 | SOURCEANDSINK | O2 (4bar) 9
Port_442784_1 | SOURCEANDSINK | O2 (4bar) 9
Port_492603_2 | SOURCEANDSINK | O2 (4bar) 9
InPort_442794_0 | SINK | O2 (4bar) 9
OutPort_442740_1 | SOURCE | O2 (4bar) 9
Port_442794_1 | SOURCEANDSINK | O2 (4bar) 9
Port_476469_1 | SOURCEANDSINK | O2 (4bar) 9
Port_442817_0 | SOURCEANDSINK | O2 (4bar) 2
Port_442829_2 | SOURCEANDSINK | O2 (4bar) 2
Port_442817_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493139_1 | SOURCEANDSINK | O2 (4bar) 2
Port_442827_1 | SOURCEANDSINK | O2 (4bar) 2
Port_442829_1 | SOURCEANDSINK | O2 (4bar) 2
InPort_443849_2 | SINK | O2 (4bar) 2
OutPort_443180_1 | SOURCE | O2 (4bar) 2
Port_443181_0 | SOURCEANDSINK | O2 (4bar) 2
Port_443845_1 | SOURCEANDSINK | O2 (4bar) 2
Port_443181_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493188_2 | SOURCEANDSINK | O2 (4bar) 2
Port_443183_0 | SOURCEANDSINK | O2 (4bar) 2
Port_443845_2 | SOURCEANDSINK | O2 (4bar) 2
Port_443183_1 | SOURCEANDSINK | O2 (4bar) 2
Port_443849_1 | SOURCEANDSINK | O2 (4bar) 2
Port_443193_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493188_1 | SOURCEANDSINK | O2 (4bar) 2
Port_443193_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493190_2 | SOURCEANDSINK | O2 (4bar) 2
InPort_443393_1 | SINK | O2 (4bar) 2
OutPort_443375_1 | SOURCE | O2 (4bar) 2
Port_443376_0 | SOURCEANDSINK | O2 (4bar) 2
Port_492380_2 | SOURCEANDSINK | O2 (4bar) 2
Port_443376_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492382_2 | SOURCEANDSINK | O2 (4bar) 2
Port_443378_0 | SOURCEANDSINK | O2 (4bar) 2
Port_443393_2 | SOURCEANDSINK | O2 (4bar) 2
Port_443378_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492382_1 | SOURCEANDSINK | O2 (4bar) 2
Port_443397_0 | SOURCEANDSINK | O2 (4bar) 2
Port_519295_1 | SOURCEANDSINK | O2 (4bar) 2
Port_443397_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493234_2 | SOURCEANDSINK | O2 (4bar) 2
InPort_492422_0 | SINK | O2 (4bar) 2
OutPort_443667_1 | SOURCE | O2 (4bar) 2
Port_443976_1 | SOURCEANDSINK | Vakuum 1
Port_492917_1 | SOURCEANDSINK | Vakuum 1
InPort_486860_0 | SINK | O2 (4bar) 3
OutPort_444017_1 | SOURCE | O2 (4bar) 3
InPort_487527_0 | SINK | O2 (4bar) 1
OutPort_444017_2 | SOURCE | O2 (4bar) 1
InPort_486915_0 | SINK | Vzduch (4bar) 2
OutPort_444017_3 | SOURCE | Vzduch (4bar) 2
InPort_487494_0 | SINK | Vzduch (4bar) 3
OutPort_444017_4 | SOURCE | Vzduch (4bar) 3
InPort_487059_0 | SINK | Vakuum 4
OutPort_444017_5 | SOURCE | Vakuum 4
InPort_487269_0 | SINK | Vakuum 1
OutPort_444017_6 | SOURCE | Vakuum 1
InPort_486887_0 | SINK | O2 (4bar) 4 (1)
OutPort_444114_1 | SOURCE | O2 (4bar) 4 (1)
InPort_487553_0 | SINK | O2 (4bar) 1
OutPort_444114_2 | SOURCE | O2 (4bar) 1
InPort_486954_0 | SINK | Vzduch (4bar) 4
OutPort_444114_3 | SOURCE | Vzduch (4bar) 4
InPort_487457_0 | SINK | Vzduch (4bar) 3
OutPort_444114_4 | SOURCE | Vzduch (4bar) 3
InPort_487030_0 | SINK | Vakuum 2
OutPort_444114_5 | SOURCE | Vakuum 2
InPort_487233_0 | SINK | Vakuum 1
OutPort_444114_6 | SOURCE | Vakuum 1
Port_444700_0 | SOURCEANDSINK | O2 (4bar) 1
Port_487646_1 | SOURCEANDSINK | O2 (4bar) 1
Port_444700_1 | SOURCEANDSINK | O2 (4bar) 1
Port_487571_1 | SOURCEANDSINK | O2 (4bar) 1
Port_444848_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487511_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_444848_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487466_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_446613_0 | SOURCEANDSINK | O2 (4bar) 3
Port_446619_2 | SOURCEANDSINK | O2 (4bar) 3
Port_446613_1 | SOURCEANDSINK | O2 (4bar) 3
Port_489855_2 | SOURCEANDSINK | O2 (4bar) 3
Port_446619_1 | SOURCEANDSINK | O2 (4bar) 3
Port_486839_0 | SOURCEANDSINK | O2 (4bar) 3
Port_446845_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_446917_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_446845_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_489851_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_446858_0 | SOURCEANDSINK | Vakuum 4
Port_446925_2 | SOURCEANDSINK | Vakuum 4
Port_446858_1 | SOURCEANDSINK | Vakuum 4
Port_489847_2 | SOURCEANDSINK | Vakuum 4
Port_446917_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_486896_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_446925_1 | SOURCEANDSINK | Vakuum 4
Port_486982_0 | SOURCEANDSINK | Vakuum 4
Port_446937_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491972_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_446937_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491940_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_446939_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_446960_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_446939_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_489839_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_446941_0 | SOURCEANDSINK | Vakuum 2
Port_446964_2 | SOURCEANDSINK | Vakuum 2
Port_446941_1 | SOURCEANDSINK | Vakuum 2
Port_489835_2 | SOURCEANDSINK | Vakuum 2
Port_446958_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_486868_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_446958_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491973_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_446960_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_486923_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_446964_1 | SOURCEANDSINK | Vakuum 2
Port_487011_0 | SOURCEANDSINK | Vakuum 2
Port_447659_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491207_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_447659_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491140_2 | SOURCEANDSINK | Vzduch (4bar) 2
InPort_476025_1 | SINK | O2 (4bar) 4 (1)
OutPort_449459_1 | SOURCE | O2 (4bar) 4 (1)
InPort_476036_1 | SINK | O2 (4bar) 4 (1)
OutPort_449471_1 | SOURCE | O2 (4bar) 4 (1)
Port_449542_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449557_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449542_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_489955_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449552_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_476025_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449552_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449554_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449554_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449557_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449560_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449654_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449560_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491988_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449629_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449643_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449629_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449658_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449639_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_476036_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449639_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449641_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449641_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449643_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449646_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449654_3 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449646_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449658_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449654_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449655_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_449655_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_489960_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_456584_1 | SOURCEANDSINK | O2 (4bar) 1
Port_492891_1 | SOURCEANDSINK | O2 (4bar) 1
InPort_456693_1 | SINK | Vakuum 1
OutPort_456691_2 | SOURCE | Vakuum 1
Port_456693_0 | SOURCEANDSINK | Vakuum 1
Port_457018_1 | SOURCEANDSINK | Vakuum 1
InPort_456745_1 | SINK | Vzduch (4bar) 3
OutPort_456743_2 | SOURCE | Vzduch (4bar) 3
Port_456745_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_457093_1 | SOURCEANDSINK | Vzduch (4bar) 3
InPort_456791_1 | SINK | O2 (4bar) 1
OutPort_456789_2 | SOURCE | O2 (4bar) 1
Port_456791_0 | SOURCEANDSINK | O2 (4bar) 1
Port_457140_1 | SOURCEANDSINK | O2 (4bar) 1
InPort_456912_0 | SINK | Vakuum 1
OutPort_456877_3 | SOURCE | Vakuum 1
Port_456912_1 | SOURCEANDSINK | Vakuum 1
Port_457029_1 | SOURCEANDSINK | Vakuum 1
Port_457006_0 | SOURCEANDSINK | Vakuum 1
Port_457026_2 | SOURCEANDSINK | Vakuum 1
Port_457006_1 | SOURCEANDSINK | Vakuum 1
Port_457029_2 | SOURCEANDSINK | Vakuum 1
Port_457018_2 | SOURCEANDSINK | Vakuum 1
Port_457019_1 | SOURCEANDSINK | Vakuum 1
Port_457018_3 | SOURCEANDSINK | Vakuum 1
Port_457026_1 | SOURCEANDSINK | Vakuum 1
InPort_457069_0 | SINK | Vzduch (4bar) 3
OutPort_457043_3 | SOURCE | Vzduch (4bar) 3
InPort_457114_0 | SINK | O2 (4bar) 1
OutPort_457052_3 | SOURCE | O2 (4bar) 1
Port_457069_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_457103_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_457083_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_457101_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_457083_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_457103_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_457093_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_457094_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_457093_3 | SOURCEANDSINK | Vzduch (4bar) 3
Port_457101_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_457114_1 | SOURCEANDSINK | O2 (4bar) 1
Port_457150_1 | SOURCEANDSINK | O2 (4bar) 1
Port_457130_0 | SOURCEANDSINK | O2 (4bar) 1
Port_457148_2 | SOURCEANDSINK | O2 (4bar) 1
Port_457130_1 | SOURCEANDSINK | O2 (4bar) 1
Port_457150_2 | SOURCEANDSINK | O2 (4bar) 1
Port_457140_2 | SOURCEANDSINK | O2 (4bar) 1
Port_457141_1 | SOURCEANDSINK | O2 (4bar) 1
Port_457140_3 | SOURCEANDSINK | O2 (4bar) 1
Port_457148_1 | SOURCEANDSINK | O2 (4bar) 1
Port_457693_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_457830_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_457693_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_474570_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_457812_1 | SOURCEANDSINK | Vakuum 2
Port_457814_1 | SOURCEANDSINK | Vakuum 2
Port_457812_2 | SOURCEANDSINK | Vakuum 2
Port_491773_0 | SOURCEANDSINK | Vakuum 2
Port_457814_2 | SOURCEANDSINK | Vakuum 2
Port_474578_0 | SOURCEANDSINK | Vakuum 2
Port_457820_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_457822_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_457820_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491815_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_457822_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474619_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_457828_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_457830_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_457828_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491860_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
OutPort_472958_1 | SOURCE
OutPort_472958_2 | SOURCE
OutPort_472958_3 | SOURCE
InPort_475169_0 | SINK | Vakuum 4
OutPort_472958_4 | SOURCE | Vakuum 4
InPort_475125_0 | SINK | Vzduch (4bar) 2
OutPort_472958_5 | SOURCE | Vzduch (4bar) 2
InPort_475220_0 | SINK | O2 (4bar) 3
OutPort_472958_6 | SOURCE | O2 (4bar) 3
OutPort_474163_1 | SOURCE | O2 (4bar) 3
OutPort_474163_2 | SOURCE | Vzduch (4bar) 2
OutPort_474163_3 | SOURCE | Vakuum 4
InPort_480000_0 | SINK | Vakuum 4
OutPort_474163_4 | SOURCE | Vakuum 4
InPort_479959_0 | SINK | Vzduch (4bar) 2
OutPort_474163_5 | SOURCE | Vzduch (4bar) 2
InPort_479913_0 | SINK | O2 (4bar) 3
OutPort_474163_6 | SOURCE | O2 (4bar) 3
OutPort_474181_1 | SOURCE
OutPort_474181_2 | SOURCE
OutPort_474181_3 | SOURCE
InPort_475407_0 | SINK | Vakuum 4
OutPort_474181_4 | SOURCE | Vakuum 4
InPort_474983_0 | SINK | Vzduch (4bar) 2
OutPort_474181_5 | SOURCE | Vzduch (4bar) 2
InPort_475896_0 | SINK | O2 (4bar) 3
OutPort_474181_6 | SOURCE | O2 (4bar) 3
OutPort_474318_1 | SOURCE
OutPort_474318_2 | SOURCE
OutPort_474318_3 | SOURCE
InPort_475452_0 | SINK | Vakuum 4
OutPort_474318_4 | SOURCE | Vakuum 4
InPort_474940_0 | SINK | Vzduch (4bar) 2
OutPort_474318_5 | SOURCE | Vzduch (4bar) 2
InPort_475853_0 | SINK | O2 (4bar) 3
OutPort_474318_6 | SOURCE | O2 (4bar) 3
OutPort_474332_1 | SOURCE
OutPort_474332_2 | SOURCE
OutPort_474332_3 | SOURCE
InPort_475495_0 | SINK | Vakuum 4
OutPort_474332_4 | SOURCE | Vakuum 4
InPort_474897_0 | SINK | Vzduch (4bar) 2
OutPort_474332_5 | SOURCE | Vzduch (4bar) 2
InPort_475806_0 | SINK | O2 (4bar) 3
OutPort_474332_6 | SOURCE | O2 (4bar) 3
OutPort_474346_1 | SOURCE
OutPort_474346_2 | SOURCE
OutPort_474346_3 | SOURCE
InPort_475540_0 | SINK | O2 (4bar) 4 (1)
OutPort_474346_4 | SOURCE | O2 (4bar) 4 (1)
InPort_474821_0 | SINK | Vzduch (4bar) 4
OutPort_474346_5 | SOURCE | Vzduch (4bar) 4
InPort_475769_0 | SINK | Vakuum 2
OutPort_474346_6 | SOURCE | Vakuum 2
OutPort_474360_1 | SOURCE
OutPort_474360_2 | SOURCE
OutPort_474360_3 | SOURCE
InPort_475726_0 | SINK | O2 (4bar) 4 (1)
OutPort_474360_4 | SOURCE | O2 (4bar) 4 (1)
InPort_474771_0 | SINK | Vzduch (4bar) 4
OutPort_474360_5 | SOURCE | Vzduch (4bar) 4
InPort_475592_0 | SINK | Vakuum 2
OutPort_474360_6 | SOURCE | Vakuum 2
OutPort_474374_1 | SOURCE
OutPort_474374_2 | SOURCE
OutPort_474374_3 | SOURCE
InPort_475683_0 | SINK | O2 (4bar) 4 (1)
OutPort_474374_4 | SOURCE | O2 (4bar) 4 (1)
InPort_474716_0 | SINK | Vzduch (4bar) 4
OutPort_474374_5 | SOURCE | Vzduch (4bar) 4
InPort_475635_0 | SINK | Vakuum 2
OutPort_474374_6 | SOURCE | Vakuum 2
OutPort_474417_1 | SOURCE
OutPort_474417_2 | SOURCE
OutPort_474417_3 | SOURCE
InPort_474604_0 | SINK | Vakuum 2
OutPort_474417_4 | SOURCE | Vakuum 2
InPort_474663_0 | SINK | Vzduch (4bar) 4
OutPort_474417_5 | SOURCE | Vzduch (4bar) 4
InPort_474534_0 | SINK | O2 (4bar) 4 (1)
OutPort_474417_6 | SOURCE | O2 (4bar) 4 (1)
Port_474520_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_474570_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_474520_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_474572_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_474534_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_474538_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_474535_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_474538_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_474535_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_474572_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_474578_1 | SOURCEANDSINK | Vakuum 2
Port_474616_1 | SOURCEANDSINK | Vakuum 2
Port_474587_0 | SOURCEANDSINK | Vakuum 2
Port_474612_2 | SOURCEANDSINK | Vakuum 2
Port_474587_1 | SOURCEANDSINK | Vakuum 2
Port_474616_2 | SOURCEANDSINK | Vakuum 2
Port_474604_1 | SOURCEANDSINK | Vakuum 2
Port_474608_1 | SOURCEANDSINK | Vakuum 2
Port_474605_0 | SOURCEANDSINK | Vakuum 2
Port_474608_2 | SOURCEANDSINK | Vakuum 2
Port_474605_1 | SOURCEANDSINK | Vakuum 2
Port_474612_1 | SOURCEANDSINK | Vakuum 2
Port_474619_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474682_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474651_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474682_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474651_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474684_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474663_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474667_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474664_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474667_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474664_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474684_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474702_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491828_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474702_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491832_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474716_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474720_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474717_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474720_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474717_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491828_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474761_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491651_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474761_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491655_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474771_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474775_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474772_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474775_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474772_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491651_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474809_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474829_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474809_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490869_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474821_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474825_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474822_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474825_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474822_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474829_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_474885_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491032_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474885_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491036_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474897_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474901_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474898_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474901_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474898_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491032_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474930_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491499_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474930_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491503_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474940_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474944_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474941_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474944_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474941_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491499_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474973_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491345_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474973_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491349_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474983_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474987_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474984_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474987_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_474984_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491345_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475035_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491331_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475035_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491140_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475113_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475200_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475113_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475202_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475125_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475129_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475126_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475129_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475126_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475202_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475157_0 | SOURCEANDSINK | Vakuum 4
Port_488574_1 | SOURCEANDSINK | Vakuum 4
Port_475157_1 | SOURCEANDSINK | Vakuum 4
Port_475192_2 | SOURCEANDSINK | Vakuum 4
Port_475169_1 | SOURCEANDSINK | Vakuum 4
Port_475173_1 | SOURCEANDSINK | Vakuum 4
Port_475170_0 | SOURCEANDSINK | Vakuum 4
Port_475173_2 | SOURCEANDSINK | Vakuum 4
Port_475170_1 | SOURCEANDSINK | Vakuum 4
Port_475192_1 | SOURCEANDSINK | Vakuum 4
Port_475198_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475200_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475198_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491208_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_475208_0 | SOURCEANDSINK | O2 (4bar) 3
Port_488581_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475208_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475243_2 | SOURCEANDSINK | O2 (4bar) 3
Port_475220_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475224_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475221_0 | SOURCEANDSINK | O2 (4bar) 3
Port_475224_2 | SOURCEANDSINK | O2 (4bar) 3
Port_475221_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475243_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475294_0 | SOURCEANDSINK | O2 (4bar) 3
Port_491290_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475294_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491138_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475347_0 | SOURCEANDSINK | Vakuum 4
Port_491406_1 | SOURCEANDSINK | Vakuum 4
Port_475347_1 | SOURCEANDSINK | Vakuum 4
Port_491142_1 | SOURCEANDSINK | Vakuum 4
Port_475397_0 | SOURCEANDSINK | Vakuum 4
Port_491420_2 | SOURCEANDSINK | Vakuum 4
Port_475397_1 | SOURCEANDSINK | Vakuum 4
Port_491424_2 | SOURCEANDSINK | Vakuum 4
Port_475407_1 | SOURCEANDSINK | Vakuum 4
Port_475411_1 | SOURCEANDSINK | Vakuum 4
Port_475408_0 | SOURCEANDSINK | Vakuum 4
Port_475411_2 | SOURCEANDSINK | Vakuum 4
Port_475408_1 | SOURCEANDSINK | Vakuum 4
Port_491420_1 | SOURCEANDSINK | Vakuum 4
Port_475440_0 | SOURCEANDSINK | Vakuum 4
Port_491537_2 | SOURCEANDSINK | Vakuum 4
Port_475440_1 | SOURCEANDSINK | Vakuum 4
Port_491541_2 | SOURCEANDSINK | Vakuum 4
Port_475452_1 | SOURCEANDSINK | Vakuum 4
Port_475456_1 | SOURCEANDSINK | Vakuum 4
Port_475453_0 | SOURCEANDSINK | Vakuum 4
Port_475456_2 | SOURCEANDSINK | Vakuum 4
Port_475453_1 | SOURCEANDSINK | Vakuum 4
Port_491537_1 | SOURCEANDSINK | Vakuum 4
Port_475485_0 | SOURCEANDSINK | Vakuum 4
Port_491073_2 | SOURCEANDSINK | Vakuum 4
Port_475485_1 | SOURCEANDSINK | Vakuum 4
Port_491077_2 | SOURCEANDSINK | Vakuum 4
Port_475495_1 | SOURCEANDSINK | Vakuum 4
Port_475499_1 | SOURCEANDSINK | Vakuum 4
Port_475496_0 | SOURCEANDSINK | Vakuum 4
Port_475499_2 | SOURCEANDSINK | Vakuum 4
Port_475496_1 | SOURCEANDSINK | Vakuum 4
Port_491073_1 | SOURCEANDSINK | Vakuum 4
Port_475528_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475548_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475528_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490865_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475540_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475544_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475541_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475544_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475541_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475548_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475578_0 | SOURCEANDSINK | Vakuum 2
Port_491606_2 | SOURCEANDSINK | Vakuum 2
Port_475578_1 | SOURCEANDSINK | Vakuum 2
Port_491610_2 | SOURCEANDSINK | Vakuum 2
Port_475592_1 | SOURCEANDSINK | Vakuum 2
Port_475596_1 | SOURCEANDSINK | Vakuum 2
Port_475593_0 | SOURCEANDSINK | Vakuum 2
Port_475596_2 | SOURCEANDSINK | Vakuum 2
Port_475593_1 | SOURCEANDSINK | Vakuum 2
Port_491606_1 | SOURCEANDSINK | Vakuum 2
Port_475625_0 | SOURCEANDSINK | Vakuum 2
Port_491786_2 | SOURCEANDSINK | Vakuum 2
Port_475625_1 | SOURCEANDSINK | Vakuum 2
Port_491790_2 | SOURCEANDSINK | Vakuum 2
Port_475635_1 | SOURCEANDSINK | Vakuum 2
Port_475639_1 | SOURCEANDSINK | Vakuum 2
Port_475636_0 | SOURCEANDSINK | Vakuum 2
Port_475639_2 | SOURCEANDSINK | Vakuum 2
Port_475636_1 | SOURCEANDSINK | Vakuum 2
Port_491786_1 | SOURCEANDSINK | Vakuum 2
Port_475669_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491873_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475669_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491877_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475683_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475687_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475684_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475687_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475684_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491873_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475716_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491692_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475716_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491696_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475726_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475730_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475727_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475730_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475727_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491692_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_475759_0 | SOURCEANDSINK | Vakuum 2
Port_475777_2 | SOURCEANDSINK | Vakuum 2
Port_475759_1 | SOURCEANDSINK | Vakuum 2
Port_490873_1 | SOURCEANDSINK | Vakuum 2
Port_475769_1 | SOURCEANDSINK | Vakuum 2
Port_475773_1 | SOURCEANDSINK | Vakuum 2
Port_475770_0 | SOURCEANDSINK | Vakuum 2
Port_475773_2 | SOURCEANDSINK | Vakuum 2
Port_475770_1 | SOURCEANDSINK | Vakuum 2
Port_475777_1 | SOURCEANDSINK | Vakuum 2
Port_475794_0 | SOURCEANDSINK | O2 (4bar) 3
Port_490991_2 | SOURCEANDSINK | O2 (4bar) 3
Port_475794_1 | SOURCEANDSINK | O2 (4bar) 3
Port_490995_2 | SOURCEANDSINK | O2 (4bar) 3
Port_475806_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475810_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475807_0 | SOURCEANDSINK | O2 (4bar) 3
Port_475810_2 | SOURCEANDSINK | O2 (4bar) 3
Port_475807_1 | SOURCEANDSINK | O2 (4bar) 3
Port_490991_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475839_0 | SOURCEANDSINK | O2 (4bar) 3
Port_491458_2 | SOURCEANDSINK | O2 (4bar) 3
Port_475839_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491462_2 | SOURCEANDSINK | O2 (4bar) 3
Port_475853_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475857_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475854_0 | SOURCEANDSINK | O2 (4bar) 3
Port_475857_2 | SOURCEANDSINK | O2 (4bar) 3
Port_475854_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491458_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475886_0 | SOURCEANDSINK | O2 (4bar) 3
Port_491304_2 | SOURCEANDSINK | O2 (4bar) 3
Port_475886_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491308_2 | SOURCEANDSINK | O2 (4bar) 3
Port_475896_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475900_1 | SOURCEANDSINK | O2 (4bar) 3
Port_475897_0 | SOURCEANDSINK | O2 (4bar) 3
Port_475900_2 | SOURCEANDSINK | O2 (4bar) 3
Port_475897_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491304_1 | SOURCEANDSINK | O2 (4bar) 3
Port_476256_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492871_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476256_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492898_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476262_0 | SOURCEANDSINK | Vakuum 1
Port_521666_1 | SOURCEANDSINK | Vakuum 1
Port_476262_1 | SOURCEANDSINK | Vakuum 1
Port_492911_1 | SOURCEANDSINK | Vakuum 1
Port_476344_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492588_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476344_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492726_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476558_0 | SOURCEANDSINK | O2 (4bar) 1
Port_492610_2 | SOURCEANDSINK | O2 (4bar) 1
Port_476558_1 | SOURCEANDSINK | O2 (4bar) 1
Port_492709_1 | SOURCEANDSINK | O2 (4bar) 1
Port_476567_0 | SOURCEANDSINK | O2 (4bar) 1
Port_492608_1 | SOURCEANDSINK | O2 (4bar) 1
Port_476567_1 | SOURCEANDSINK | O2 (4bar) 1
Port_476584_2 | SOURCEANDSINK | O2 (4bar) 1
Port_476578_0 | SOURCEANDSINK | O2 (4bar) 1
Port_476584_1 | SOURCEANDSINK | O2 (4bar) 1
Port_476578_1 | SOURCEANDSINK | O2 (4bar) 1
Port_476595_1 | SOURCEANDSINK | O2 (4bar) 1
Port_476587_0 | SOURCEANDSINK | O2 (4bar) 1
Port_476595_2 | SOURCEANDSINK | O2 (4bar) 1
Port_476587_1 | SOURCEANDSINK | O2 (4bar) 1
Port_480854_1 | SOURCEANDSINK | O2 (4bar) 1
Port_476642_0 | SOURCEANDSINK | O2 (4bar) 1
Port_480766_1 | SOURCEANDSINK | O2 (4bar) 1
Port_476642_1 | SOURCEANDSINK | O2 (4bar) 1
Port_480715_1 | SOURCEANDSINK | O2 (4bar) 1
Port_476653_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492586_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476653_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476715_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476659_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476680_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476659_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476715_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476666_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476810_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476666_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476680_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476675_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476810_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476675_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485513_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476757_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485450_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476757_1 | SOURCEANDSINK | Vzduch (4bar) 3
InPort_476867_2 | SINK | Vzduch (4bar) 3
OutPort_476865_1 | SOURCE | Vzduch (4bar) 3
OutPort_476865_2 | SOURCE
Port_476867_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485451_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_476913_0 | SOURCEANDSINK | Vakuum 1
Port_476921_1 | SOURCEANDSINK | Vakuum 1
Port_476913_1 | SOURCEANDSINK | Vakuum 1
Port_476971_0 | SOURCEANDSINK | O2 (4bar) 1
Port_492860_1 | SOURCEANDSINK | O2 (4bar) 1
Port_476971_1 | SOURCEANDSINK | O2 (4bar) 1
Port_492715_1 | SOURCEANDSINK | O2 (4bar) 1
Port_477020_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492869_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_477020_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492732_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_477040_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492728_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_477040_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492732_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_477060_0 | SOURCEANDSINK | O2 (4bar) 1
Port_492711_2 | SOURCEANDSINK | O2 (4bar) 1
Port_477060_1 | SOURCEANDSINK | O2 (4bar) 1
Port_492715_2 | SOURCEANDSINK | O2 (4bar) 1
InPort_479085_2 | SINK | O2 (4bar) 2
OutPort_479074_1 | SOURCE | O2 (4bar) 2
Port_479075_0 | SOURCEANDSINK | O2 (4bar) 2
Port_479083_1 | SOURCEANDSINK | O2 (4bar) 2
Port_479075_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493546_2 | SOURCEANDSINK | O2 (4bar) 2
Port_479077_0 | SOURCEANDSINK | O2 (4bar) 2
Port_479083_2 | SOURCEANDSINK | O2 (4bar) 2
Port_479077_1 | SOURCEANDSINK | O2 (4bar) 2
Port_479085_1 | SOURCEANDSINK | O2 (4bar) 2
Port_479079_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493546_1 | SOURCEANDSINK | O2 (4bar) 2
Port_479079_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493548_2 | SOURCEANDSINK | O2 (4bar) 2
InPort_479188_2 | SINK | O2 (4bar) 2
OutPort_479177_1 | SOURCE | O2 (4bar) 2
Port_479178_0 | SOURCEANDSINK | O2 (4bar) 2
Port_479186_1 | SOURCEANDSINK | O2 (4bar) 2
Port_479178_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493431_1 | SOURCEANDSINK | O2 (4bar) 2
Port_479180_0 | SOURCEANDSINK | O2 (4bar) 2
Port_479186_2 | SOURCEANDSINK | O2 (4bar) 2
Port_479180_1 | SOURCEANDSINK | O2 (4bar) 2
Port_479188_1 | SOURCEANDSINK | O2 (4bar) 2
Port_479182_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493431_2 | SOURCEANDSINK | O2 (4bar) 2
Port_479182_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493433_2 | SOURCEANDSINK | O2 (4bar) 2
InPort_479315_2 | SINK | O2 (4bar) 2
OutPort_479306_1 | SOURCE | O2 (4bar) 2
Port_479309_0 | SOURCEANDSINK | O2 (4bar) 2
Port_492255_1 | SOURCEANDSINK | O2 (4bar) 2
Port_479309_1 | SOURCEANDSINK | O2 (4bar) 2
Port_479315_1 | SOURCEANDSINK | O2 (4bar) 2
Port_479311_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493489_1 | SOURCEANDSINK | O2 (4bar) 2
Port_479311_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493491_2 | SOURCEANDSINK | O2 (4bar) 2
Port_479499_0 | SOURCEANDSINK | Vakuum 1
Port_492913_2 | SOURCEANDSINK | Vakuum 1
Port_479499_1 | SOURCEANDSINK | Vakuum 1
Port_492917_2 | SOURCEANDSINK | Vakuum 1
Port_479582_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492900_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_479582_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492904_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_479618_0 | SOURCEANDSINK | O2 (4bar) 1
Port_492887_2 | SOURCEANDSINK | O2 (4bar) 1
Port_479618_1 | SOURCEANDSINK | O2 (4bar) 1
Port_492891_2 | SOURCEANDSINK | O2 (4bar) 1
Port_479901_0 | SOURCEANDSINK | O2 (4bar) 3
Port_491262_2 | SOURCEANDSINK | O2 (4bar) 3
Port_479901_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491266_2 | SOURCEANDSINK | O2 (4bar) 3
Port_479913_1 | SOURCEANDSINK | O2 (4bar) 3
Port_479917_1 | SOURCEANDSINK | O2 (4bar) 3
Port_479914_0 | SOURCEANDSINK | O2 (4bar) 3
Port_479917_2 | SOURCEANDSINK | O2 (4bar) 3
Port_479914_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491262_1 | SOURCEANDSINK | O2 (4bar) 3
Port_479947_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491221_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_479947_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491225_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_479959_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_479963_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_479960_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_479963_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_479960_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491221_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_479988_0 | SOURCEANDSINK | Vakuum 4
Port_491180_2 | SOURCEANDSINK | Vakuum 4
Port_479988_1 | SOURCEANDSINK | Vakuum 4
Port_491184_2 | SOURCEANDSINK | Vakuum 4
Port_480000_1 | SOURCEANDSINK | Vakuum 4
Port_480004_1 | SOURCEANDSINK | Vakuum 4
Port_480001_0 | SOURCEANDSINK | Vakuum 4
Port_480004_2 | SOURCEANDSINK | Vakuum 4
Port_480001_1 | SOURCEANDSINK | Vakuum 4
Port_491180_1 | SOURCEANDSINK | Vakuum 4
Port_480225_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487467_0 | SOURCEANDSINK | Vzduch (4bar) 3
InPort_480715_2 | SINK | O2 (4bar) 1
OutPort_480711_1 | SOURCE | O2 (4bar) 1
OutPort_480711_2 | SOURCE
Port_480756_0 | SOURCEANDSINK | O2 (4bar) 1
Port_480766_3 | SOURCEANDSINK | O2 (4bar) 1
Port_480756_1 | SOURCEANDSINK | O2 (4bar) 1
Port_480860_1 | SOURCEANDSINK | O2 (4bar) 1
Port_480766_2 | SOURCEANDSINK | O2 (4bar) 1
Port_480767_1 | SOURCEANDSINK | O2 (4bar) 1
Port_480767_0 | SOURCEANDSINK | O2 (4bar) 1
Port_480772_0 | SOURCEANDSINK | O2 (4bar) 1
Port_481320_2 | SOURCEANDSINK | O2 (4bar) 1
Port_480772_1 | SOURCEANDSINK | O2 (4bar) 1
Port_480862_2 | SOURCEANDSINK | O2 (4bar) 1
Port_480852_0 | SOURCEANDSINK | O2 (4bar) 1
Port_480854_2 | SOURCEANDSINK | O2 (4bar) 1
Port_480852_1 | SOURCEANDSINK | O2 (4bar) 1
Port_480862_1 | SOURCEANDSINK | O2 (4bar) 1
Port_480860_2 | SOURCEANDSINK | O2 (4bar) 1
Port_480938_0 | SOURCEANDSINK | O2 (4bar) 1
InPort_481528_0 | SINK | O2 (4bar) 1
OutPort_480936_1 | SOURCE | O2 (4bar) 1
InPort_480938_1 | SINK | O2 (4bar) 1
OutPort_480936_2 | SOURCE | O2 (4bar) 1
InPort_481283_0 | SINK | O2 (4bar) 1
OutPort_481070_3 | SOURCE | O2 (4bar) 1
Port_481283_1 | SOURCEANDSINK | O2 (4bar) 1
Port_481331_1 | SOURCEANDSINK | O2 (4bar) 1
Port_481297_0 | SOURCEANDSINK | O2 (4bar) 1
Port_481328_2 | SOURCEANDSINK | O2 (4bar) 1
Port_481297_1 | SOURCEANDSINK | O2 (4bar) 1
Port_481331_2 | SOURCEANDSINK | O2 (4bar) 1
Port_481320_1 | SOURCEANDSINK | O2 (4bar) 1
Port_481321_1 | SOURCEANDSINK | O2 (4bar) 1
Port_481320_3 | SOURCEANDSINK | O2 (4bar) 1
Port_481328_1 | SOURCEANDSINK | O2 (4bar) 1
Port_481321_0 | SOURCEANDSINK | O2 (4bar) 1
Port_481527_2 | SOURCEANDSINK | O2 (4bar) 1
Port_481414_0 | SOURCEANDSINK | O2 (4bar) 9
Port_485280_2 | SOURCEANDSINK | O2 (4bar) 9
Port_481414_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481422_2 | SOURCEANDSINK | O2 (4bar) 9
InPort_481418_0 | SINK | O2 (4bar) 9
OutPort_481417_3 | SOURCE | O2 (4bar) 9
Port_481418_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481428_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481420_0 | SOURCEANDSINK | O2 (4bar) 9
Port_481451_2 | SOURCEANDSINK | O2 (4bar) 9
Port_481420_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481428_2 | SOURCEANDSINK | O2 (4bar) 9
Port_481422_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481574_0 | SOURCEANDSINK | O2 (4bar) 9
Port_481422_3 | SOURCEANDSINK | O2 (4bar) 9
Port_481451_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481423_0 | SOURCEANDSINK | O2 (4bar) 1
Port_481572_2 | SOURCEANDSINK | O2 (4bar) 1
Port_481423_1 | SOURCEANDSINK | O2 (4bar) 1
Port_481538_1 | SOURCEANDSINK | O2 (4bar) 1
Port_481515_0 | SOURCEANDSINK | O2 (4bar) 1
Port_481535_2 | SOURCEANDSINK | O2 (4bar) 1
Port_481515_1 | SOURCEANDSINK | O2 (4bar) 1
Port_481538_2 | SOURCEANDSINK | O2 (4bar) 1
Port_481527_1 | SOURCEANDSINK | O2 (4bar) 1
Port_481528_1 | SOURCEANDSINK | O2 (4bar) 1
Port_481527_3 | SOURCEANDSINK | O2 (4bar) 1
Port_481535_1 | SOURCEANDSINK | O2 (4bar) 1
InPort_481574_1 | SINK | O2 (4bar) 9
OutPort_481572_1 | SOURCE | O2 (4bar) 9
Port_481681_0 | SOURCEANDSINK | O2 (4bar) 9
Port_481702_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481681_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481964_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481690_0 | SOURCEANDSINK | O2 (4bar) 9
Port_492597_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481690_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481702_2 | SOURCEANDSINK | O2 (4bar) 9
Port_481836_0 | SOURCEANDSINK | O2 (4bar) 9
Port_492599_2 | SOURCEANDSINK | O2 (4bar) 9
Port_481836_1 | SOURCEANDSINK | O2 (4bar) 9
Port_492603_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481912_0 | SOURCEANDSINK | O2 (4bar) 9
Port_485280_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481912_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481962_2 | SOURCEANDSINK | O2 (4bar) 9
Port_481927_0 | SOURCEANDSINK | O2 (4bar) 9
Port_481962_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481927_1 | SOURCEANDSINK | O2 (4bar) 9
Port_481964_2 | SOURCEANDSINK | O2 (4bar) 9
InPort_482180_1 | SINK | O2 (4bar) 2
OutPort_482175_1 | SOURCE | O2 (4bar) 2
Port_482176_0 | SOURCEANDSINK | O2 (4bar) 2
Port_482186_1 | SOURCEANDSINK | O2 (4bar) 2
Port_482176_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493287_2 | SOURCEANDSINK | O2 (4bar) 2
Port_482178_0 | SOURCEANDSINK | O2 (4bar) 2
Port_482180_2 | SOURCEANDSINK | O2 (4bar) 2
Port_482178_1 | SOURCEANDSINK | O2 (4bar) 2
Port_482186_2 | SOURCEANDSINK | O2 (4bar) 2
Port_482182_0 | SOURCEANDSINK | O2 (4bar) 2
Port_519243_2 | SOURCEANDSINK | O2 (4bar) 2
Port_482182_1 | SOURCEANDSINK | O2 (4bar) 2
Port_519247_2 | SOURCEANDSINK | O2 (4bar) 2
Port_482352_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493532_1 | SOURCEANDSINK | O2 (4bar) 2
Port_482352_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493139_2 | SOURCEANDSINK | O2 (4bar) 2
Port_485388_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485446_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485388_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485450_3 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485390_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485513_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485390_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485403_2 | SOURCEANDSINK | Vzduch (4bar) 3
InPort_485404_1 | SINK | Vzduch (4bar) 3
OutPort_485395_1 | SOURCE | Vzduch (4bar) 3
InPort_485396_1 | SINK | Vzduch (4bar) 3
OutPort_485395_2 | SOURCE | Vzduch (4bar) 3
Port_485396_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485446_1 | SOURCEANDSINK | Vzduch (4bar) 3
InPort_485399_0 | SINK | Vzduch (4bar) 3
OutPort_485398_3 | SOURCE | Vzduch (4bar) 3
Port_485399_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485409_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485401_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485407_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485401_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485409_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485403_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485404_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485403_3 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485407_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485450_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_485451_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_486839_1 | SOURCEANDSINK | O2 (4bar) 3
Port_486866_2 | SOURCEANDSINK | O2 (4bar) 3
Port_486850_0 | SOURCEANDSINK | O2 (4bar) 3
Port_486862_2 | SOURCEANDSINK | O2 (4bar) 3
Port_486850_1 | SOURCEANDSINK | O2 (4bar) 3
Port_486866_1 | SOURCEANDSINK | O2 (4bar) 3
Port_486860_1 | SOURCEANDSINK | O2 (4bar) 3
Port_486862_1 | SOURCEANDSINK | O2 (4bar) 3
Port_486868_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_486893_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_486877_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_486889_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_486877_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_486893_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_486887_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_486889_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_486896_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_486921_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_486905_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_486917_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_486905_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_486921_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_486915_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_486917_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_486923_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_486974_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_486942_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_486974_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_486942_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_486976_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_486954_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_486976_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_486982_1 | SOURCEANDSINK | Vakuum 4
Port_487074_2 | SOURCEANDSINK | Vakuum 4
Port_487011_1 | SOURCEANDSINK | Vakuum 2
Port_487036_2 | SOURCEANDSINK | Vakuum 2
Port_487020_0 | SOURCEANDSINK | Vakuum 2
Port_487032_2 | SOURCEANDSINK | Vakuum 2
Port_487020_1 | SOURCEANDSINK | Vakuum 2
Port_487036_1 | SOURCEANDSINK | Vakuum 2
Port_487030_1 | SOURCEANDSINK | Vakuum 2
Port_487032_1 | SOURCEANDSINK | Vakuum 2
Port_487049_0 | SOURCEANDSINK | Vakuum 4
Port_487074_1 | SOURCEANDSINK | Vakuum 4
Port_487049_1 | SOURCEANDSINK | Vakuum 4
Port_487076_2 | SOURCEANDSINK | Vakuum 4
Port_487059_1 | SOURCEANDSINK | Vakuum 4
Port_487076_1 | SOURCEANDSINK | Vakuum 4
Port_487225_0 | SOURCEANDSINK | Vakuum 1
Port_487391_2 | SOURCEANDSINK | Vakuum 1
Port_487225_1 | SOURCEANDSINK | Vakuum 1
Port_487395_2 | SOURCEANDSINK | Vakuum 1
Port_487233_1 | SOURCEANDSINK | Vakuum 1
Port_487391_1 | SOURCEANDSINK | Vakuum 1
Port_487247_0 | SOURCEANDSINK | Vakuum 1
Port_487376_1 | SOURCEANDSINK | Vakuum 1
Port_487247_1 | SOURCEANDSINK | Vakuum 1
Port_487352_1 | SOURCEANDSINK | Vakuum 1
Port_487261_0 | SOURCEANDSINK | Vakuum 1
Port_487271_2 | SOURCEANDSINK | Vakuum 1
Port_487261_1 | SOURCEANDSINK | Vakuum 1
Port_487284_2 | SOURCEANDSINK | Vakuum 1
Port_487269_1 | SOURCEANDSINK | Vakuum 1
Port_487271_1 | SOURCEANDSINK | Vakuum 1
Port_487284_1 | SOURCEANDSINK | Vakuum 1
Port_487286_1 | SOURCEANDSINK | Vakuum 1
Port_487286_2 | SOURCEANDSINK | Vakuum 1
Port_487377_0 | SOURCEANDSINK | Vakuum 1
Port_487374_0 | SOURCEANDSINK | Vakuum 1
Port_487384_2 | SOURCEANDSINK | Vakuum 1
Port_487374_1 | SOURCEANDSINK | Vakuum 1
Port_487395_1 | SOURCEANDSINK | Vakuum 1
Port_487376_2 | SOURCEANDSINK | Vakuum 1
Port_487377_1 | SOURCEANDSINK | Vakuum 1
Port_487376_3 | SOURCEANDSINK | Vakuum 1
Port_487384_1 | SOURCEANDSINK | Vakuum 1
Port_487445_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487476_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487445_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487480_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487457_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487480_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487464_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487474_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487464_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487476_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487466_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487467_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487466_3 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487474_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487484_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487496_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487484_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487509_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487494_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487496_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487509_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487511_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_487515_0 | SOURCEANDSINK | O2 (4bar) 1
Port_487529_2 | SOURCEANDSINK | O2 (4bar) 1
Port_487515_1 | SOURCEANDSINK | O2 (4bar) 1
Port_487567_2 | SOURCEANDSINK | O2 (4bar) 1
Port_487527_1 | SOURCEANDSINK | O2 (4bar) 1
Port_487529_1 | SOURCEANDSINK | O2 (4bar) 1
Port_487543_0 | SOURCEANDSINK | O2 (4bar) 1
Port_487660_2 | SOURCEANDSINK | O2 (4bar) 1
Port_487543_1 | SOURCEANDSINK | O2 (4bar) 1
Port_487664_2 | SOURCEANDSINK | O2 (4bar) 1
Port_487553_1 | SOURCEANDSINK | O2 (4bar) 1
Port_487660_1 | SOURCEANDSINK | O2 (4bar) 1
Port_487567_1 | SOURCEANDSINK | O2 (4bar) 1
Port_487569_1 | SOURCEANDSINK | O2 (4bar) 1
Port_487569_2 | SOURCEANDSINK | O2 (4bar) 1
Port_487647_0 | SOURCEANDSINK | O2 (4bar) 1
Port_487644_0 | SOURCEANDSINK | O2 (4bar) 1
Port_487654_2 | SOURCEANDSINK | O2 (4bar) 1
Port_487644_1 | SOURCEANDSINK | O2 (4bar) 1
Port_487664_1 | SOURCEANDSINK | O2 (4bar) 1
Port_487646_2 | SOURCEANDSINK | O2 (4bar) 1
Port_487647_1 | SOURCEANDSINK | O2 (4bar) 1
Port_487646_3 | SOURCEANDSINK | O2 (4bar) 1
Port_487654_1 | SOURCEANDSINK | O2 (4bar) 1
Port_488427_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491678_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_488427_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491565_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_488471_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491637_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_488471_1 | SOURCEANDSINK | Vzduch (4bar) 4
