Properties of the parts of a building model (IFC2X3), part 5 of 5

# IfcFlowSegment: Typy trubek:Měď - EN 13348 - pájení natvrdo (350)
Name (Typy trubek:Měď - EN 13348 - pájení natvrdo:...) | In | Length (mm) = Délka (mm) | Celková velikost = Velikost | Výška dolní hrany AllplanAttributes dole (mm) = Výška dolní hrany dole (mm) | Výška dolní hrany AllplanAttributes nahoře (mm) = Výška dolní hrany nahoře (mm) | Výška horní hrany AllplanAttributes dole (mm) = Výška horní hrany dole (mm) | Výška horní hrany AllplanAttributes nahoře (mm) = Výška horní hrany nahoře (mm) | CS_SCHEDULEID = ID | CS_SCHEDULETYPEID | Relativní drsnost | Kód prvku | Podlaží | Koncová výška osy (mm) | Počáteční výška osy (mm) = Výška osy (mm) | Referenční podlaží | Sklon | Výška dna trubky dole (mm) | Výška dna trubky nahoře (mm) | Výška osy dole (mm) | Výška osy nahoře (mm) | Výška stropu trubky dole (mm) | Výška stropu trubky nahoře (mm) | Fáze vytvoření | Drsnost (mm) | Materiál | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) = Vnější průměr (mm) | Řez | Teplonosná látka | Úsek potrubí | Výkaz/typ | Tloustka (mm) | Vnitřní průměr (mm) | Komentáře | Group
486850 | Půdorys 1.NP | 152.24 | 18 mm | 2941 | 2941 | 2959 | 2959 | 486850 | 432495 | 0.00015875 | TR.03.486850 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.00860897 | 18 | 1 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 3
486860 | Půdorys 1.NP | 1115.62 | 18 mm | 1800 | 2915.62 | 1800 | 2915.62 | 486860 | 432495 | 0 | TR.03.486860 | Podlaží 1.NP | 2915.62 | 1800 | Podlaží 1.NP |  | 1800 | 2915.62 | 1800 | 2915.62 | 1800 | 2915.62 | Nová konstrukce | 0.00254 | Kov - Měď | 1800 | 0.0630868 | 18 | 1 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 3
486868 | Půdorys 1.NP | 5778.74 | 18 mm | 2941 | 2941 | 2959 | 2959 | 486868 | 432495 | 0.00015875 | TR.03.486868 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.32678 | 18 | 51 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 4 (1)
486877 | Půdorys 1.NP | 377.24 | 18 mm | 2941 | 2941 | 2959 | 2959 | 486877 | 432495 | 0.00015875 | TR.03.486877 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0213324 | 18 | 51 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 4 (1)
486887 | Půdorys 1.NP | 1115.62 | 18 mm | 1800 | 2915.62 | 1800 | 2915.62 | 486887 | 432495 | 0 | TR.03.486887 | Podlaží 1.NP | 2915.62 | 1800 | Podlaží 1.NP |  | 1800 | 2915.62 | 1800 | 2915.62 | 1800 | 2915.62 | Nová konstrukce | 0.00254 | Kov - Měď | 1800 | 0.0630868 | 18 | 51 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 4 (1)
486896 | Půdorys 1.NP | 5317.74 | 18 mm | 2941 | 2941 | 2959 | 2959 | 486896 | 432495 | 0.00015875 | TR.03.486896 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.300711 | 18 | 1 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 2
486905 | Půdorys 1.NP | 227.24 | 18 mm | 2941 | 2941 | 2959 | 2959 | 486905 | 432495 | 0.00015875 | TR.03.486905 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0128501 | 18 | 1 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 2
486915 | Půdorys 1.NP | 1115.62 | 18 mm | 1800 | 2915.62 | 1800 | 2915.62 | 486915 | 432495 | 0 | TR.03.486915 | Podlaží 1.NP | 2915.62 | 1800 | Podlaží 1.NP |  | 1800 | 2915.62 | 1800 | 2915.62 | 1800 | 2915.62 | Nová konstrukce | 0.00254 | Kov - Měď | 1800 | 0.0630868 | 18 | 1 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 2
486923 | Půdorys 1.NP | 5948.74 | 18 mm | 2941 | 2941 | 2959 | 2959 | 486923 | 432495 | 0.00015875 | TR.03.486923 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.336393 | 18 | 1 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 4
486942 | Půdorys 1.NP | 452.24 | 18 mm | 2941 | 2941 | 2959 | 2959 | 486942 | 432495 | 0.00015875 | TR.03.486942 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0255736 | 18 | 1 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 4
486954 | Půdorys 1.NP | 1115.62 | 18 mm | 1800 | 2915.62 | 1800 | 2915.62 | 486954 | 432495 | 0 | TR.03.486954 | Podlaží 1.NP | 2915.62 | 1800 | Podlaží 1.NP |  | 1800 | 2915.62 | 1800 | 2915.62 | 1800 | 2915.62 | Nová konstrukce | 0.00254 | Kov - Měď | 1800 | 0.0630868 | 18 | 1 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 4
486982 | Půdorys 1.NP | 5487.74 | 18 mm | 2941 | 2941 | 2959 | 2959 | 486982 | 432495 | 0.00015875 | TR.03.486982 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.310324 | 18 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 4
487011 | Půdorys 1.NP | 6118.74 | 18 mm | 2941 | 2941 | 2959 | 2959 | 487011 | 432495 | 0.00015875 | TR.03.487011 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.346007 | 18 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 2
487020 | Půdorys 1.NP | 527.24 | 18 mm | 2941 | 2941 | 2959 | 2959 | 487020 | 432495 | 0.00015875 | TR.03.487020 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0298147 | 18 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 2
487030 | Půdorys 1.NP | 1115.62 | 18 mm | 1800 | 2915.62 | 1800 | 2915.62 | 487030 | 432495 | 0 | TR.03.487030 | Podlaží 1.NP | 2915.62 | 1800 | Podlaží 1.NP |  | 1800 | 2915.62 | 1800 | 2915.62 | 1800 | 2915.62 | Nová konstrukce | 0.00254 | Kov - Měď | 1800 | 0.0630868 | 18 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 2
487049 | Půdorys 1.NP | 302.24 | 18 mm | 2941 | 2941 | 2959 | 2959 | 487049 | 432495 | 0.00015875 | TR.03.487049 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0170913 | 18 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 4
487059 | Půdorys 1.NP | 1115.62 | 18 mm | 1800 | 2915.62 | 1800 | 2915.62 | 487059 | 432495 | 0 | TR.03.487059 | Podlaží 1.NP | 2915.62 | 1800 | Podlaží 1.NP |  | 1800 | 2915.62 | 1800 | 2915.62 | 1800 | 2915.62 | Nová konstrukce | 0.00254 | Kov - Měď | 1800 | 0.0630868 | 18 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 4
487225 | Půdorys 1.NP | 152.24 | 18 mm | 2891 | 2891 | 2909 | 2909 | 487225 | 432495 | 0.00015875 | TR.03.487225 | Podlaží 1.NP | 2900 | 2900 | Podlaží 1.NP | 0 | 2892 | 2892 | 2900 | 2900 | 2908 | 2908 | Nová konstrukce | 0.00254 | Kov - Měď | 2892 | 0.00860897 | 18 | 36 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 1
487233 | Půdorys 1.NP | 1065.62 | 18 mm | 1800 | 2865.62 | 1800 | 2865.62 | 487233 | 432495 | 0 | TR.03.487233 | Podlaží 1.NP | 2865.62 | 1800 | Podlaží 1.NP |  | 1800 | 2865.62 | 1800 | 2865.62 | 1800 | 2865.62 | Nová konstrukce | 0.00254 | Kov - Měď | 1800 | 0.0602594 | 18 | 36 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 1
487247 | Půdorys 1.NP | 828.683 | 22 mm | 2689 | 2689 | 2711 | 2711 | 487247 | 432495 | 0.000127 | TR.03.487247 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2690 | 2690 | 2700 | 2700 | 2710 | 2710 | Nová konstrukce | 0.00254 | Kov - Měď | 2690 | 0.0572745 | 22 | 40 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vakuum 1
487261 | Půdorys 1.NP | 152.24 | 18 mm | 2691 | 2691 | 2709 | 2709 | 487261 | 432495 | 0.00015875 | TR.03.487261 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2692 | 2692 | 2700 | 2700 | 2708 | 2708 | Nová konstrukce | 0.00254 | Kov - Měď | 2692 | 0.00860897 | 18 | 35 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 1
487269 | Půdorys 1.NP | 865.62 | 18 mm | 1800 | 2665.62 | 1800 | 2665.62 | 487269 | 432495 | 0 | TR.03.487269 | Podlaží 1.NP | 2665.62 | 1800 | Podlaží 1.NP |  | 1800 | 2665.62 | 1800 | 2665.62 | 1800 | 2665.62 | Nová konstrukce | 0.00254 | Kov - Měď | 1800 | 0.0489497 | 18 | 35 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 1
487374 | Půdorys 1.NP | 106.94 | 18 mm | 2758.68 | 2865.62 | 2758.68 | 2865.62 | 487374 | 432495 | 0 | TR.03.487374 | Podlaží 1.NP | 2865.62 | 2758.68 | Podlaží 1.NP |  | 2758.68 | 2865.62 | 2758.68 | 2865.62 | 2758.68 | 2865.62 | Nová konstrukce | 0.00254 | Kov - Měď | 2758.68 | 0.00604731 | 18 | 36 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 1
487377 | Půdorys 1.NP | 309.84 | 22 mm | 2689 | 2689 | 2711 | 2711 | 487377 | 432495 | 0.000127 | TR.03.487377 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2690 | 2690 | 2700 | 2700 | 2710 | 2710 | Nová konstrukce | 0.00254 | Kov - Měď | 2690 | 0.0214146 | 22 | 38 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vakuum 1
487445 | Půdorys 1.NP | 227.24 | 18 mm | 2891 | 2891 | 2909 | 2909 | 487445 | 432495 | 0.00015875 | TR.03.487445 | Podlaží 1.NP | 2900 | 2900 | Podlaží 1.NP | 0 | 2892 | 2892 | 2900 | 2900 | 2908 | 2908 | Nová konstrukce | 0.00254 | Kov - Měď | 2892 | 0.0128501 | 18 | 55 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 3
487457 | Půdorys 1.NP | 1065.62 | 18 mm | 1800 | 2865.62 | 1800 | 2865.62 | 487457 | 432495 | 0 | TR.03.487457 | Podlaží 1.NP | 2865.62 | 1800 | Podlaží 1.NP |  | 1800 | 2865.62 | 1800 | 2865.62 | 1800 | 2865.62 | Nová konstrukce | 0.00254 | Kov - Měď | 1800 | 0.0602594 | 18 | 55 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 3
487464 | Půdorys 1.NP | 106.94 | 18 mm | 2758.68 | 2865.62 | 2758.68 | 2865.62 | 487464 | 432495 | 0 | TR.03.487464 | Podlaží 1.NP | 2865.62 | 2758.68 | Podlaží 1.NP |  | 2758.68 | 2865.62 | 2758.68 | 2865.62 | 2758.68 | 2865.62 | Nová konstrukce | 0.00254 | Kov - Měď | 2758.68 | 0.00604731 | 18 | 55 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 3
487467 | Půdorys 1.NP | 773.683 | 22 mm | 2689 | 2689 | 2711 | 2711 | 487467 | 432495 | 0.000127 | TR.03.487467 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2690 | 2690 | 2700 | 2700 | 2710 | 2710 | Nová konstrukce | 0.00254 | Kov - Měď | 2690 | 0.0534731 | 22 | 22 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vzduch (4bar) 3
487484 | Půdorys 1.NP | 227.24 | 18 mm | 2691 | 2691 | 2709 | 2709 | 487484 | 432495 | 0.00015875 | TR.03.487484 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2692 | 2692 | 2700 | 2700 | 2708 | 2708 | Nová konstrukce | 0.00254 | Kov - Měď | 2692 | 0.0128501 | 18 | 54 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 3
487494 | Půdorys 1.NP | 865.62 | 18 mm | 1800 | 2665.62 | 1800 | 2665.62 | 487494 | 432495 | 0 | TR.03.487494 | Podlaží 1.NP | 2665.62 | 1800 | Podlaží 1.NP |  | 1800 | 2665.62 | 1800 | 2665.62 | 1800 | 2665.62 | Nová konstrukce | 0.00254 | Kov - Měď | 1800 | 0.0489497 | 18 | 54 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 3
487515 | Půdorys 1.NP | 302.24 | 18 mm | 2691 | 2691 | 2709 | 2709 | 487515 | 432495 | 0.00015875 | TR.03.487515 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2692 | 2692 | 2700 | 2700 | 2708 | 2708 | Nová konstrukce | 0.00254 | Kov - Měď | 2692 | 0.0170913 | 18 | 57 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 1
487527 | Půdorys 1.NP | 865.62 | 18 mm | 1800 | 2665.62 | 1800 | 2665.62 | 487527 | 432495 | 0 | TR.03.487527 | Podlaží 1.NP | 2665.62 | 1800 | Podlaží 1.NP |  | 1800 | 2665.62 | 1800 | 2665.62 | 1800 | 2665.62 | Nová konstrukce | 0.00254 | Kov - Měď | 1800 | 0.0489497 | 18 | 57 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 1
487543 | Půdorys 1.NP | 302.24 | 18 mm | 2891 | 2891 | 2909 | 2909 | 487543 | 432495 | 0.00015875 | TR.03.487543 | Podlaží 1.NP | 2900 | 2900 | Podlaží 1.NP | 0 | 2892 | 2892 | 2900 | 2900 | 2908 | 2908 | Nová konstrukce | 0.00254 | Kov - Měď | 2892 | 0.0170913 | 18 | 58 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 1
487553 | Půdorys 1.NP | 1065.62 | 18 mm | 1800 | 2865.62 | 1800 | 2865.62 | 487553 | 432495 | 0 | TR.03.487553 | Podlaží 1.NP | 2865.62 | 1800 | Podlaží 1.NP |  | 1800 | 2865.62 | 1800 | 2865.62 | 1800 | 2865.62 | Nová konstrukce | 0.00254 | Kov - Měď | 1800 | 0.0602594 | 18 | 58 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 1
487644 | Půdorys 1.NP | 106.94 | 18 mm | 2758.68 | 2865.62 | 2758.68 | 2865.62 | 487644 | 432495 | 0 | TR.03.487644 | Podlaží 1.NP | 2865.62 | 2758.68 | Podlaží 1.NP |  | 2758.68 | 2865.62 | 2758.68 | 2865.62 | 2758.68 | 2865.62 | Nová konstrukce | 0.00254 | Kov - Měď | 2758.68 | 0.00604731 | 18 | 58 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 1
487647 | Půdorys 1.NP | 309.84 | 22 mm | 2689 | 2689 | 2711 | 2711 | 487647 | 432495 | 0.000127 | TR.03.487647 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2690 | 2690 | 2700 | 2700 | 2710 | 2710 | Nová konstrukce | 0.00254 | Kov - Měď | 2690 | 0.0214146 | 22 | 40 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | O2 (4bar) 1
488427 | Půdorys 1.NP | 1635.62 | 18 mm | 2941 | 2941 | 2959 | 2959 | 488427 | 432495 | 0.00015875 | TR.03.488427 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0924921 | 18 | 3 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 4 (1)
488471 | Půdorys 1.NP | 1610.62 | 18 mm | 2941 | 2941 | 2959 | 2959 | 488471 | 432495 | 0.00015875 | TR.03.488471 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0910784 | 18 | 6 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 4
488512 | Půdorys 1.NP | 1585.62 | 18 mm | 2941 | 2941 | 2959 | 2959 | 488512 | 432495 | 0.00015875 | TR.03.488512 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0896647 | 18 | 6 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 2
489008 | Půdorys 1.NP | 1394.06 | 18 mm | 2941 | 2941 | 2959 | 2959 | 489008 | 432495 | 0.00015875 | TR.03.489008 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0788325 | 18 | 12 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 4
489091 | Půdorys 1.NP | 1294.06 | 18 mm | 2941 | 2941 | 2959 | 2959 | 489091 | 432495 | 0.00015875 | TR.03.489091 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0731776 | 18 | 12 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 3
489590 | Půdorys 1.NP | 8096.16 | 18 mm | 2941 | 2941 | 2959 | 2959 | 489590 | 432495 | 0.00015875 | TR.03.489590 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.457827 | 18 | 1 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 3
489592 | Půdorys 1.NP | 8246.16 | 18 mm | 2941 | 2941 | 2959 | 2959 | 489592 | 432495 | 0.00015875 | TR.03.489592 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.466309 | 18 | 1 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 2
489594 | Půdorys 1.NP | 8396.16 | 18 mm | 2941 | 2941 | 2959 | 2959 | 489594 | 432495 | 0.00015875 | TR.03.489594 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.474791 | 18 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 4
489596 | Půdorys 1.NP | 8471.16 | 18 mm | 2941 | 2941 | 2959 | 2959 | 489596 | 432495 | 0.00015875 | TR.03.489596 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.479033 | 18 | 75 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 4 (1)
489598 | Půdorys 1.NP | 8471.16 | 18 mm | 2941 | 2941 | 2959 | 2959 | 489598 | 432495 | 0.00015875 | TR.03.489598 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.479033 | 18 | 1 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 4
489600 | Půdorys 1.NP | 8471.16 | 18 mm | 2941 | 2941 | 2959 | 2959 | 489600 | 432495 | 0.00015875 | TR.03.489600 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.479033 | 18 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 2
489687 | Půdorys 1.NP | 1087.42 | 18 mm | 2941 | 2941 | 2959 | 2959 | 489687 | 432495 | 0.00015875 | TR.03.489687 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0614923 | 18 | 1 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 |  | O2 (4bar) 3
489750 | Půdorys 1.NP | 1087.42 | 18 mm | 2941 | 2941 | 2959 | 2959 | 489750 | 432495 | 0.00015875 | TR.03.489750 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0614923 | 18 | 1 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 |  | Vzduch (4bar) 2
489766 | Půdorys 1.NP | 1087.42 | 18 mm | 2941 | 2941 | 2959 | 2959 | 489766 | 432495 | 0.00015875 | TR.03.489766 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0614923 | 18 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 |  | Vakuum 4
489774 | Půdorys 1.NP | 1087.42 | 18 mm | 2941 | 2941 | 2959 | 2959 | 489774 | 432495 | 0.00015875 | TR.03.489774 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0614923 | 18 | 75 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 |  | O2 (4bar) 4 (1)
489782 | Půdorys 1.NP | 1087.42 | 18 mm | 2941 | 2941 | 2959 | 2959 | 489782 | 432495 | 0.00015875 | TR.03.489782 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0614923 | 18 | 1 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 |  | Vzduch (4bar) 4
489790 | Půdorys 1.NP | 1087.42 | 18 mm | 2941 | 2941 | 2959 | 2959 | 489790 | 432495 | 0.00015875 | TR.03.489790 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0614923 | 18 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 |  | Vakuum 2
489902 | Půdorys 1.NP | 2542.42 | 12 mm | 2859 | 2859 | 2871 | 2871 | 489902 | 432495 | 0.000254 | TR.03.489902 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0958469 | 12 | 68 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
489929 | Půdorys 1.NP | 352.36 | 12 mm | 2859 | 2859 | 2871 | 2871 | 489929 | 432495 | 0.000254 | TR.03.489929 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0132837 | 12 | 68 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 4 (1)
490102 | Půdorys 1.NP | 1393.35 | 18 mm | 3041 | 3041 | 3059 | 3059 | 490102 | 432495 | 0.00015875 | TR.03.490102 | Podlaží 1.NP | 3050 | 3050 | Podlaží 1.NP | 0 | 3042 | 3042 | 3050 | 3050 | 3058 | 3058 | Nová konstrukce | 0.00254 | Kov - Měď | 3042 | 0.0787923 | 18 | 66 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 4 (1)
490104 | Půdorys 1.NP | 1493.35 | 18 mm | 3041 | 3041 | 3059 | 3059 | 490104 | 432495 | 0.00015875 | TR.03.490104 | Podlaží 1.NP | 3050 | 3050 | Podlaží 1.NP | 0 | 3042 | 3042 | 3050 | 3050 | 3058 | 3058 | Nová konstrukce | 0.00254 | Kov - Měď | 3042 | 0.0844472 | 18 | 3 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 4
490106 | Půdorys 1.NP | 1593.35 | 18 mm | 3041 | 3041 | 3059 | 3059 | 490106 | 432495 | 0.00015875 | TR.03.490106 | Podlaží 1.NP | 3050 | 3050 | Podlaží 1.NP | 0 | 3042 | 3042 | 3050 | 3050 | 3058 | 3058 | Nová konstrukce | 0.00254 | Kov - Měď | 3042 | 0.090102 | 18 | 3 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 2
490543 | Půdorys 1.NP | 31.24 | 18 mm | 2984.38 | 3015.62 | 2984.38 | 3015.62 | 490543 | 432495 | 0 | TR.03.490543 | Podlaží 1.NP | 3015.62 | 2984.38 | Podlaží 1.NP |  | 2984.38 | 3015.62 | 2984.38 | 3015.62 | 2984.38 | 3015.62 | Nová konstrukce | 0.00254 | Kov - Měď | 2984.38 | 0.00176658 | 18 | 6 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 |  | Vakuum 2
490575 | Půdorys 1.NP | 31.24 | 18 mm | 2984.38 | 3015.62 | 2984.38 | 3015.62 | 490575 | 432495 | 0 | TR.03.490575 | Podlaží 1.NP | 3015.62 | 2984.38 | Podlaží 1.NP |  | 2984.38 | 3015.62 | 2984.38 | 3015.62 | 2984.38 | 3015.62 | Nová konstrukce | 0.00254 | Kov - Měď | 2984.38 | 0.00176658 | 18 | 6 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 |  | Vzduch (4bar) 4
490604 | Půdorys 1.NP | 31.24 | 18 mm | 2984.38 | 3015.62 | 2984.38 | 3015.62 | 490604 | 432495 | 0 | TR.03.490604 | Podlaží 1.NP | 3015.62 | 2984.38 | Podlaží 1.NP |  | 2984.38 | 3015.62 | 2984.38 | 3015.62 | 2984.38 | 3015.62 | Nová konstrukce | 0.00254 | Kov - Měď | 2984.38 | 0.00176658 | 18 | 3 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 |  | O2 (4bar) 4 (1)
490637 | Půdorys 1.NP | 42.72 | 18 mm | 2984.38 | 3027.1 | 2984.38 | 3027.1 | 490637 | 432495 | 0 | TR.03.490637 | Podlaží 1.NP | 2984.38 | 3027.1 | Podlaží 1.NP |  | 2984.38 | 3027.1 | 2984.38 | 3027.1 | 2984.38 | 3027.1 | Nová konstrukce | 0.00254 | Kov - Měď | 2984.38 | 0.00241576 | 18 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 |  | Vakuum 2
490640 | Půdorys 1.NP | 135.029 | 18 mm | 3041 | 3041 | 3059 | 3059 | 490640 | 432495 | 0.00015875 | TR.03.490640 | Podlaží 1.NP | 3050 | 3050 | Podlaží 1.NP | 0 | 3042 | 3042 | 3050 | 3050 | 3058 | 3058 | Nová konstrukce | 0.00254 | Kov - Měď | 3042 | 0.00763574 | 18 | 6 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 2
490670 | Půdorys 1.NP | 42.72 | 18 mm | 2984.38 | 3027.1 | 2984.38 | 3027.1 | 490670 | 432495 | 0 | TR.03.490670 | Podlaží 1.NP | 2984.38 | 3027.1 | Podlaží 1.NP |  | 2984.38 | 3027.1 | 2984.38 | 3027.1 | 2984.38 | 3027.1 | Nová konstrukce | 0.00254 | Kov - Měď | 2984.38 | 0.00241576 | 18 | 1 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 |  | Vzduch (4bar) 4
490673 | Půdorys 1.NP | 210.029 | 18 mm | 3041 | 3041 | 3059 | 3059 | 490673 | 432495 | 0.00015875 | TR.03.490673 | Podlaží 1.NP | 3050 | 3050 | Podlaží 1.NP | 0 | 3042 | 3042 | 3050 | 3050 | 3058 | 3058 | Nová konstrukce | 0.00254 | Kov - Měď | 3042 | 0.0118769 | 18 | 6 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 4
490700 | Půdorys 1.NP | 42.72 | 18 mm | 2984.38 | 3027.1 | 2984.38 | 3027.1 | 490700 | 432495 | 0 | TR.03.490700 | Podlaží 1.NP | 2984.38 | 3027.1 | Podlaží 1.NP |  | 2984.38 | 3027.1 | 2984.38 | 3027.1 | 2984.38 | 3027.1 | Nová konstrukce | 0.00254 | Kov - Měď | 2984.38 | 0.00241576 | 18 | 75 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 |  | O2 (4bar) 4 (1)
490703 | Půdorys 1.NP | 285.029 | 18 mm | 3041 | 3041 | 3059 | 3059 | 490703 | 432495 | 0.00015875 | TR.03.490703 | Podlaží 1.NP | 3050 | 3050 | Podlaží 1.NP | 0 | 3042 | 3042 | 3050 | 3050 | 3058 | 3058 | Nová konstrukce | 0.00254 | Kov - Měď | 3042 | 0.016118 | 18 | 3 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 4 (1)
490975 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 490975 | 432495 | 0 | TR.03.490975 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 10 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 3
490978 | Půdorys 1.NP | 4741.81 | 18 mm | 2941 | 2941 | 2959 | 2959 | 490978 | 432495 | 0.00015875 | TR.03.490978 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.268143 | 18 | 1 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 3
491016 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491016 | 432495 | 0 | TR.03.491016 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 10 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | Vzduch (4bar) 2
491019 | Půdorys 1.NP | 4791.81 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491019 | 432495 | 0.00015875 | TR.03.491019 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.270971 | 18 | 1 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 2
491057 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491057 | 432495 | 0 | TR.03.491057 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 10 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | Vakuum 4
491060 | Půdorys 1.NP | 4841.81 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491060 | 432495 | 0.00015875 | TR.03.491060 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.273798 | 18 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 4
491164 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491164 | 432495 | 0 | TR.03.491164 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 6 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | Vakuum 4
491167 | Půdorys 1.NP | 2480.72 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491167 | 432495 | 0.00015875 | TR.03.491167 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.140282 | 18 | 3 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 4
491205 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491205 | 432495 | 0 | TR.03.491205 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 6 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | Vzduch (4bar) 2
491208 | Půdorys 1.NP | 2480.72 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491208 | 432495 | 0.00015875 | TR.03.491208 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.140282 | 18 | 3 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 2
491246 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491246 | 432495 | 0 | TR.03.491246 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 6 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 3
491249 | Půdorys 1.NP | 2480.72 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491249 | 432495 | 0.00015875 | TR.03.491249 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.140282 | 18 | 3 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 3
491288 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491288 | 432495 | 0 | TR.03.491288 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 8 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 3
491291 | Půdorys 1.NP | 3492.06 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491291 | 432495 | 0.00015875 | TR.03.491291 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.197471 | 18 | 15 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 3
491329 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491329 | 432495 | 0 | TR.03.491329 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 8 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | Vzduch (4bar) 2
491332 | Půdorys 1.NP | 3492.06 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491332 | 432495 | 0.00015875 | TR.03.491332 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.197471 | 18 | 15 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 2
491404 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491404 | 432495 | 0 | TR.03.491404 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 8 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | Vakuum 4
491407 | Půdorys 1.NP | 3492.06 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491407 | 432495 | 0.00015875 | TR.03.491407 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.197471 | 18 | 15 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 4
491442 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491442 | 432495 | 0 | TR.03.491442 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 9 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 3
491445 | Půdorys 1.NP | 3449.5 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491445 | 432495 | 0.00015875 | TR.03.491445 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.195064 | 18 | 4 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 3
491483 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491483 | 432495 | 0 | TR.03.491483 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 9 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | Vzduch (4bar) 2
491486 | Půdorys 1.NP | 3449.5 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491486 | 432495 | 0.00015875 | TR.03.491486 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.195064 | 18 | 4 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 2
491521 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491521 | 432495 | 0 | TR.03.491521 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 9 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | Vakuum 4
491524 | Půdorys 1.NP | 3449.5 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491524 | 432495 | 0.00015875 | TR.03.491524 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.195064 | 18 | 4 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 4
491590 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491590 | 432495 | 0 | TR.03.491590 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 4 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | Vakuum 2
491593 | Půdorys 1.NP | 3427.9 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491593 | 432495 | 0.00015875 | TR.03.491593 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.193843 | 18 | 8 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 2
491635 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491635 | 432495 | 0 | TR.03.491635 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 4 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | Vzduch (4bar) 4
491638 | Půdorys 1.NP | 3427.9 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491638 | 432495 | 0.00015875 | TR.03.491638 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.193843 | 18 | 9 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 4
491676 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491676 | 432495 | 0 | TR.03.491676 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 71 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 4 (1)
491679 | Půdorys 1.NP | 3427.9 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491679 | 432495 | 0.00015875 | TR.03.491679 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.193843 | 18 | 69 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 4 (1)
491770 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491770 | 432495 | 0 | TR.03.491770 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 11 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | Vakuum 2
491773 | Půdorys 1.NP | 1722.75 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491773 | 432495 | 0.00015875 | TR.03.491773 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0974194 | 18 | 9 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 2
491812 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491812 | 432495 | 0 | TR.03.491812 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 7 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | Vzduch (4bar) 4
491815 | Půdorys 1.NP | 1772.75 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491815 | 432495 | 0.00015875 | TR.03.491815 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.100247 | 18 | 10 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 4
491857 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491857 | 432495 | 0 | TR.03.491857 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 1 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 4 (1)
491860 | Půdorys 1.NP | 1822.75 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491860 | 432495 | 0.00015875 | TR.03.491860 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.103074 | 18 | 72 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 4 (1)
491970 | Půdorys 1.NP | 4.26 | 12 mm | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 491970 | 432495 | 0 | TR.03.491970 | Podlaží 1.NP | 2888.82 | 2893.08 | Podlaží 1.NP |  | 2888.82 | 2893.08 | 2888.82 | 2893.08 | 2888.82 | 2893.08 | Nová konstrukce | 0.00254 | Kov - Měď | 2888.82 | 0.000160598 | 12 | 48 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 4 (1)
491973 | Půdorys 1.NP | 9846.99 | 18 mm | 2941 | 2941 | 2959 | 2959 | 491973 | 432495 | 0.00015875 | TR.03.491973 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.556834 | 18 | 51 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 4 (1)
492217 | Půdorys 1.PP | 770.36 | 12 mm | 2744 | 2744 | 2756 | 2756 | 492217 | 432495 | 0.000254 | TR.02.492217 | Podlaží 1.NP | 2750 | 2750 | Podlaží 1.PP | 0 | 2745 | 2745 | 2750 | 2750 | 2755 | 2755 | Nová konstrukce | 0.00254 | Kov - Měď | -555 | 0.0290419 | 12 | 15 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 2
492294 | Půdorys 1.PP | 2729.5 | 12 mm | 2659 | 2659 | 2671 | 2671 | 492294 | 432495 | 0.000254 | TR.02.492294 | Podlaží 1.NP | 2665 | 2665 | Podlaží 1.PP | 0 | 2660 | 2660 | 2665 | 2665 | 2670 | 2670 | Nová konstrukce | 0.00254 | Kov - Měď | -640 | 0.1029 | 12 | 6 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
492356 | Půdorys 1.PP | 462.36 | 12 mm | 2659 | 2659 | 2671 | 2671 | 492356 | 432495 | 0.000254 | TR.02.492356 | Podlaží 1.NP | 2665 | 2665 | Podlaží 1.PP | 0 | 2660 | 2660 | 2665 | 2665 | 2670 | 2670 | Nová konstrukce | 0.00254 | Kov - Měď | -640 | 0.0174306 | 12 | 6 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 2
492406 | Půdorys 1.PP | 1770.1 | 12 mm | 2654 | 2654 | 2666 | 2666 | 492406 | 432495 | 0.000254 | TR.02.492406 | Podlaží 1.NP | 2660 | 2660 | Podlaží 1.PP | 0 | 2655 | 2655 | 2660 | 2660 | 2665 | 2665 | Nová konstrukce | 0.00254 | Kov - Měď | -645 | 0.0667312 | 12 | 9 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 2
492422 | Půdorys 1.PP | 1193.5 | 10 mm | 1446.2 | 2639.7 | 1446.2 | 2639.7 | 492422 | 432495 | 0 | TR.02.492422 | Podlaží 1.NP | 2639.7 | 1446.2 | Podlaží 1.PP |  | 1446.2 | 2639.7 | 1446.2 | 2639.7 | 1446.2 | 2639.7 | Nová konstrukce | 0 |  | -1853.8 | 0.0374949 | 10 | 8 | O2 |  |  | 0 | 10 |  | O2 (4bar) 2
492443 | Půdorys 1.PP | 4262.36 | 12 mm | 2654 | 2654 | 2666 | 2666 | 492443 | 432495 | 0.000254 | TR.02.492443 | Podlaží 1.NP | 2660 | 2660 | Podlaží 1.PP | 0 | 2655 | 2655 | 2660 | 2660 | 2665 | 2665 | Nová konstrukce | 0.00254 | Kov - Měď | -645 | 0.160687 | 12 | 9 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 2
492454 | Půdorys 1.PP | 992.36 | 12 mm | 2654 | 2654 | 2666 | 2666 | 492454 | 432495 | 0.000254 | TR.02.492454 | Podlaží 1.NP | 2660 | 2660 | Podlaží 1.PP | 0 | 2655 | 2655 | 2660 | 2660 | 2665 | 2665 | Nová konstrukce | 0.00254 | Kov - Měď | -645 | 0.0374111 | 12 | 9 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 2
492463 | Půdorys 1.PP | 1932.72 | 12 mm | 2554 | 2554 | 2566 | 2566 | 492463 | 432495 | 0.000254 | TR.02.492463 | Podlaží 1.NP | 2560 | 2560 | Podlaží 1.PP | 0 | 2555 | 2555 | 2560 | 2560 | 2565 | 2565 | Nová konstrukce | 0.00254 | Kov - Měď | -745 | 0.0728619 | 12 | 9 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
492584 | Půdorys 1.PP | 46.04 | 28 mm | 2461.98 | 2508.02 | 2461.98 | 2508.02 | 492584 | 432495 | 0 | TR.02.492584 | Podlaží 1.NP | 2461.98 | 2508.02 | Podlaží 1.PP |  | 2461.98 | 2508.02 | 2461.98 | 2508.02 | 2461.98 | 2508.02 | Nová konstrukce | 0.00254 | Kov - Měď | -838.02 | 0.00404989 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 |  | Vzduch (4bar) 3
492595 | Půdorys 1.PP | 81.24 | 18 mm | 2444.38 | 2525.62 | 2444.38 | 2525.62 | 492595 | 432495 | 0 | TR.02.492595 | Podlaží 1.NP | 2444.38 | 2525.62 | Podlaží 1.PP |  | 2444.38 | 2525.62 | 2444.38 | 2525.62 | 2444.38 | 2525.62 | Nová konstrukce | 0.00254 | Kov - Měď | -855.62 | 0.00459401 | 18 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 |  | O2 (4bar) 9
492606 | Půdorys 1.PP | 46.04 | 28 mm | 2461.98 | 2508.02 | 2461.98 | 2508.02 | 492606 | 432495 | 0 | TR.02.492606 | Podlaží 1.NP | 2461.98 | 2508.02 | Podlaží 1.PP |  | 2461.98 | 2508.02 | 2461.98 | 2508.02 | 2461.98 | 2508.02 | Nová konstrukce | 0.00254 | Kov - Měď | -838.02 | 0.00404989 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 |  | O2 (4bar) 1
492707 | Půdorys 1.PP | 6.04 | 28 mm | 2461.98 | 2468.02 | 2461.98 | 2468.02 | 492707 | 432495 | 0 | TR.02.492707 | Podlaží 1.NP | 2468.02 | 2461.98 | Podlaží 1.PP |  | 2461.98 | 2468.02 | 2461.98 | 2468.02 | 2461.98 | 2468.02 | Nová konstrukce | 0.00254 | Kov - Měď | -838.02 | 0.000531306 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 |  | O2 (4bar) 1
492724 | Půdorys 1.PP | 6.04 | 28 mm | 2461.98 | 2468.02 | 2461.98 | 2468.02 | 492724 | 432495 | 0 | TR.02.492724 | Podlaží 1.NP | 2468.02 | 2461.98 | Podlaží 1.PP |  | 2461.98 | 2468.02 | 2461.98 | 2468.02 | 2461.98 | 2468.02 | Nová konstrukce | 0.00254 | Kov - Měď | -838.02 | 0.000531306 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 |  | Vzduch (4bar) 3
492858 | Půdorys 1.PP | 176.04 | 28 mm | 2571.98 | 2748.02 | 2571.98 | 2748.02 | 492858 | 432495 | 0 | TR.02.492858 | Podlaží 1.NP | 2748.02 | 2571.98 | Podlaží 1.PP |  | 2571.98 | 2748.02 | 2571.98 | 2748.02 | 2571.98 | 2748.02 | Nová konstrukce | 0.00254 | Kov - Měď | -728.02 | 0.0154853 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 |  | O2 (4bar) 1
492867 | Půdorys 1.PP | 176.04 | 28 mm | 2571.98 | 2748.02 | 2571.98 | 2748.02 | 492867 | 432495 | 0 | TR.02.492867 | Podlaží 1.NP | 2748.02 | 2571.98 | Podlaží 1.PP |  | 2571.98 | 2748.02 | 2571.98 | 2748.02 | 2571.98 | 2748.02 | Nová konstrukce | 0.00254 | Kov - Měď | -728.02 | 0.0154853 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 |  | Vzduch (4bar) 3
492883 | Půdorys 1.PP | 46.04 | 28 mm | 2701.98 | 2748.02 | 2701.98 | 2748.02 | 492883 | 432495 | 0 | TR.02.492883 | Podlaží 1.NP | 2701.98 | 2748.02 | Podlaží 1.PP |  | 2701.98 | 2748.02 | 2701.98 | 2748.02 | 2701.98 | 2748.02 | Nová konstrukce | 0.00254 | Kov - Měď | -598.02 | 0.00404989 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 |  | O2 (4bar) 1
492896 | Půdorys 1.PP | 46.04 | 28 mm | 2701.98 | 2748.02 | 2701.98 | 2748.02 | 492896 | 432495 | 0 | TR.02.492896 | Podlaží 1.NP | 2701.98 | 2748.02 | Podlaží 1.PP |  | 2701.98 | 2748.02 | 2701.98 | 2748.02 | 2701.98 | 2748.02 | Nová konstrukce | 0.00254 | Kov - Měď | -598.02 | 0.00404989 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 |  | Vzduch (4bar) 3
492909 | Půdorys 1.PP | 46.04 | 28 mm | 2701.98 | 2748.02 | 2701.98 | 2748.02 | 492909 | 432495 | 0 | TR.02.492909 | Podlaží 1.NP | 2701.98 | 2748.02 | Podlaží 1.PP |  | 2701.98 | 2748.02 | 2701.98 | 2748.02 | 2701.98 | 2748.02 | Nová konstrukce | 0.00254 | Kov - Měď | -598.02 | 0.00404989 | 28 | 42 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 |  | Vakuum 1
493172 | Půdorys 1.PP | 189.26 | 12 mm | 2466.92 | 2656.18 | 2466.92 | 2656.18 | 493172 | 432495 | 0 | TR.02.493172 | Podlaží 1.NP | 2656.18 | 2466.92 | Podlaží 1.PP |  | 2466.92 | 2656.18 | 2466.92 | 2656.18 | 2466.92 | 2656.18 | Nová konstrukce | 0.00254 | Kov - Měď | -833.08 | 0.00713493 | 12 | 3 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 2
493175 | Půdorys 1.PP | 3729.27 | 18 mm | 2401 | 2401 | 2419 | 2419 | 493175 | 432495 | 0.00015875 | TR.02.493175 | Podlaží 1.NP | 2410 | 2410 | Podlaží 1.PP | 0 | 2402 | 2402 | 2410 | 2410 | 2418 | 2418 | Nová konstrukce | 0.00254 | Kov - Měď | -898 | 0.210885 | 18 | 7 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 2
493224 | Půdorys 1.PP | 57.78 | 12 mm | 2478.4 | 2536.18 | 2478.4 | 2536.18 | 493224 | 432495 | 0 | TR.02.493224 | Podlaží 1.NP | 2536.18 | 2478.4 | Podlaží 1.PP |  | 2478.4 | 2536.18 | 2478.4 | 2536.18 | 2478.4 | 2536.18 | Nová konstrukce | 0.00254 | Kov - Měď | -821.6 | 0.00217825 | 12 | 6 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 2
493271 | Půdorys 1.PP | 69.26 | 12 mm | 2466.92 | 2536.18 | 2466.92 | 2536.18 | 493271 | 432495 | 0 | TR.02.493271 | Podlaží 1.NP | 2536.18 | 2466.92 | Podlaží 1.PP |  | 2466.92 | 2536.18 | 2466.92 | 2536.18 | 2466.92 | 2536.18 | Nová konstrukce | 0.00254 | Kov - Měď | -833.08 | 0.00261104 | 12 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 2
493274 | Půdorys 1.PP | 1298.35 | 18 mm | 2401 | 2401 | 2419 | 2419 | 493274 | 432495 | 0.00015875 | TR.02.493274 | Podlaží 1.NP | 2410 | 2410 | Podlaží 1.PP | 0 | 2402 | 2402 | 2410 | 2410 | 2418 | 2418 | Nová konstrukce | 0.00254 | Kov - Měď | -898 | 0.0734198 | 18 | 1 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 2
493333 | Půdorys 1.PP | 69.26 | 12 mm | 2466.92 | 2536.18 | 2466.92 | 2536.18 | 493333 | 432495 | 0 | TR.02.493333 | Podlaží 1.NP | 2536.18 | 2466.92 | Podlaží 1.PP |  | 2466.92 | 2536.18 | 2466.92 | 2536.18 | 2466.92 | 2536.18 | Nová konstrukce | 0.00254 | Kov - Měď | -833.08 | 0.00261104 | 12 | 9 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 2
493336 | Půdorys 1.PP | 3493.15 | 18 mm | 2401 | 2401 | 2419 | 2419 | 493336 | 432495 | 0.00015875 | TR.02.493336 | Podlaží 1.NP | 2410 | 2410 | Podlaží 1.PP | 0 | 2402 | 2402 | 2410 | 2410 | 2418 | 2418 | Nová konstrukce | 0.00254 | Kov - Měď | -898 | 0.197533 | 18 | 25 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 2
493415 | Půdorys 1.PP | 259.26 | 12 mm | 2466.92 | 2726.18 | 2466.92 | 2726.18 | 493415 | 432495 | 0 | TR.02.493415 | Podlaží 1.NP | 2726.18 | 2466.92 | Podlaží 1.PP |  | 2466.92 | 2726.18 | 2466.92 | 2726.18 | 2466.92 | 2726.18 | Nová konstrukce | 0.00254 | Kov - Měď | -833.08 | 0.00977387 | 12 | 13 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 2
493418 | Půdorys 1.PP | 3402.85 | 18 mm | 2401 | 2401 | 2419 | 2419 | 493418 | 432495 | 0.00015875 | TR.02.493418 | Podlaží 1.NP | 2410 | 2410 | Podlaží 1.PP | 0 | 2402 | 2402 | 2410 | 2410 | 2418 | 2418 | Nová konstrukce | 0.00254 | Kov - Měď | -898 | 0.192426 | 18 | 20 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 2
493473 | Půdorys 1.PP | 259.26 | 12 mm | 2466.92 | 2726.18 | 2466.92 | 2726.18 | 493473 | 432495 | 0 | TR.02.493473 | Podlaží 1.NP | 2726.18 | 2466.92 | Podlaží 1.PP |  | 2466.92 | 2726.18 | 2466.92 | 2726.18 | 2466.92 | 2726.18 | Nová konstrukce | 0.00254 | Kov - Měď | -833.08 | 0.00977387 | 12 | 15 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 2
493476 | Půdorys 1.PP | 4798 | 18 mm | 2401 | 2401 | 2419 | 2419 | 493476 | 432495 | 0.00015875 | TR.02.493476 | Podlaží 1.NP | 2410 | 2410 | Podlaží 1.PP | 0 | 2402 | 2402 | 2410 | 2410 | 2418 | 2418 | Nová konstrukce | 0.00254 | Kov - Měď | -898 | 0.271321 | 18 | 19 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 2
493530 | Půdorys 1.PP | 259.26 | 12 mm | 2466.92 | 2726.18 | 2466.92 | 2726.18 | 493530 | 432495 | 0 | TR.02.493530 | Podlaží 1.NP | 2726.18 | 2466.92 | Podlaží 1.PP |  | 2466.92 | 2726.18 | 2466.92 | 2726.18 | 2466.92 | 2726.18 | Nová konstrukce | 0.00254 | Kov - Měď | -833.08 | 0.00977387 | 12 | 11 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 2
493533 | Půdorys 1.PP | 3111.09 | 18 mm | 2401 | 2401 | 2419 | 2419 | 493533 | 432495 | 0.00015875 | TR.02.493533 | Podlaží 1.NP | 2410 | 2410 | Podlaží 1.PP | 0 | 2402 | 2402 | 2410 | 2410 | 2418 | 2418 | Nová konstrukce | 0.00254 | Kov - Měď | -898 | 0.175928 | 18 | 23 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 2
518912 | Půdorys 1.PP | 2760.15 | 12 mm | 2654 | 2654 | 2666 | 2666 | 518912 | 432495 | 0.000254 | TR.02.518912 | Podlaží 1.NP | 2660 | 2660 | Podlaží 1.PP | 0 | 2655 | 2655 | 2660 | 2660 | 2665 | 2665 | Nová konstrukce | 0.00254 | Kov - Měď | -645 | 0.104055 | 12 | 9 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
518962 | Půdorys 1.PP | 52.36 | 12 mm | 2583.82 | 2636.18 | 2583.82 | 2636.18 | 518962 | 432495 | 0 | TR.02.518962 | Podlaží 1.NP | 2636.18 | 2583.82 | Podlaží 1.PP |  | 2583.82 | 2636.18 | 2583.82 | 2636.18 | 2583.82 | 2636.18 | Nová konstrukce | 0.00254 | Kov - Měď | -716.18 | 0.00197393 | 12 | 9 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
519080 | Půdorys 1.PP | 3700.54 | 12 mm | 2744 | 2744 | 2756 | 2756 | 519080 | 432495 | 0.000254 | TR.02.519080 | Podlaží 1.NP | 2750 | 2750 | Podlaží 1.PP | 0 | 2745 | 2745 | 2750 | 2750 | 2755 | 2755 | Nová konstrukce | 0.00254 | Kov - Měď | -555 | 0.139507 | 12 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
519150 | Půdorys 1.PP | 1995.45 | 12 mm | 2554 | 2554 | 2566 | 2566 | 519150 | 432495 | 0.000254 | TR.02.519150 | Podlaží 1.NP | 2560 | 2560 | Podlaží 1.PP | 0 | 2555 | 2555 | 2560 | 2560 | 2565 | 2565 | Nová konstrukce | 0.00254 | Kov - Měď | -745 | 0.0752269 | 12 | 6 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
519233 | Půdorys 1.PP | 142.36 | 12 mm | 2583.82 | 2726.18 | 2583.82 | 2726.18 | 519233 | 432495 | 0 | TR.02.519233 | Podlaží 1.NP | 2583.82 | 2726.18 | Podlaží 1.PP |  | 2583.82 | 2726.18 | 2583.82 | 2726.18 | 2583.82 | 2726.18 | Nová konstrukce | 0.00254 | Kov - Měď | -716.18 | 0.00536685 | 12 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 2
519293 | Půdorys 1.PP | 57.36 | 12 mm | 2583.82 | 2641.18 | 2583.82 | 2641.18 | 519293 | 432495 | 0 | TR.02.519293 | Podlaží 1.NP | 2583.82 | 2641.18 | Podlaží 1.PP |  | 2583.82 | 2641.18 | 2583.82 | 2641.18 | 2583.82 | 2641.18 | Nová konstrukce | 0.00254 | Kov - Měď | -716.18 | 0.00216242 | 12 | 6 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 |  | O2 (4bar) 2
521592 | Půdorys 1.PP | 1361.14 | 28 mm | 2936 | 2936 | 2964 | 2964 | 476262 | 432495 | 0.0001016 | TR.02.476262 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.PP | 0 | 2937.5 | 2937.5 | 2950 | 2950 | 2962.5 | 2962.5 | Nová konstrukce | 0.00254 | Kov - Měď | -362.5 | 0.119732 | 28 | 42 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vakuum 1
521664 | Půdorys 1.PP | 46.04 | 28 mm | 2851.98 | 2898.02 | 2851.98 | 2898.02 |  |  | 0 |  |  | 2898.02 | 2851.98 | Podlaží 1.PP |  | 2851.98 | 2898.02 | 2851.98 | 2898.02 | 2851.98 | 2898.02 | Nová konstrukce | 0.00254 | Kov - Měď | -448.02 | 0.00404989 | 28 | 42 | Vakuum | Kov - Měď - EN 13348 | EN 13348 |  | 25 |  | Vakuum 1
