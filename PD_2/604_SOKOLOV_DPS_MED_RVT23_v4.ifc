Properties of the parts of a building model (IFC2X3), part 3 of 5

# IfcFlowFitting: Koleno ohyb - pájení natvrdo - CU:Standard (246)
Name (Koleno ohyb - pájení natvrdo - CU:Standard:...) | In | NominalDiameter = Fitting Outside Diameter (mm) = Maximální velikost (mm) = Průměr (mm) | Celková velikost = Velikost | CS_SCHEDULEID = ID | CS_SCHEDULETYPEID | Kód prvku | Podlaží | Výška od podlaží (mm) | Teplonosná látka | Centre to End (mm) = Length 1 (mm) = Length 2 (mm) | Nominal Radius (mm) = Fitting Outside Radius (mm) | Objem (m3) | Socket Outside Diameter (mm) | Socket Width (mm) | Tick Size (mm) | Wall Thickness (mm) | Komentáře | Centre Radius (mm) = Length 3 (mm) = Length 4 (mm) | Socket Outside Radius (mm) | Group
491308 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491308 | 257978 | TT.03.491308 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 3
491345 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491345 | 257978 | TT.03.491345 | Podlaží 1.NP | 2865 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 2
491349 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491349 | 257978 | TT.03.491349 | Podlaží 1.NP | 2865 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | Vzduch (4bar) 2
491420 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491420 | 257978 | TT.03.491420 | Podlaží 1.NP | 2865 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 4
491424 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491424 | 257978 | TT.03.491424 | Podlaží 1.NP | 2865 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | Vakuum 4
491458 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491458 | 257978 | TT.03.491458 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 3
491462 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491462 | 257978 | TT.03.491462 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 3
491499 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491499 | 257978 | TT.03.491499 | Podlaží 1.NP | 2865 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 2
491503 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491503 | 257978 | TT.03.491503 | Podlaží 1.NP | 2865 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | Vzduch (4bar) 2
491537 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491537 | 257978 | TT.03.491537 | Podlaží 1.NP | 2865 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 4
491541 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491541 | 257978 | TT.03.491541 | Podlaží 1.NP | 2865 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | Vakuum 4
491565 | Půdorys 1.NP | 18 | 18 mm-18 mm | 491565 | 257978 | TT.03.491565 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | O2 (4bar) 4 (1)
491569 | Půdorys 1.NP | 18 | 18 mm-18 mm | 491569 | 257978 | TT.03.491569 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vzduch (4bar) 4
491573 | Půdorys 1.NP | 18 | 18 mm-18 mm | 491573 | 257978 | TT.03.491573 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vakuum 2
491606 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491606 | 257978 | TT.03.491606 | Podlaží 1.NP | 2865 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 2
491610 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491610 | 257978 | TT.03.491610 | Podlaží 1.NP | 2865 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | Vakuum 2
491651 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491651 | 257978 | TT.03.491651 | Podlaží 1.NP | 2865 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 4
491655 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491655 | 257978 | TT.03.491655 | Podlaží 1.NP | 2865 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | Vzduch (4bar) 4
491692 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491692 | 257978 | TT.03.491692 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 4 (1)
491696 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491696 | 257978 | TT.03.491696 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 4 (1)
491786 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491786 | 257978 | TT.03.491786 | Podlaží 1.NP | 2865 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 2
491790 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491790 | 257978 | TT.03.491790 | Podlaží 1.NP | 2865 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | Vakuum 2
491828 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491828 | 257978 | TT.03.491828 | Podlaží 1.NP | 2865 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 4
491832 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491832 | 257978 | TT.03.491832 | Podlaží 1.NP | 2865 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | Vzduch (4bar) 4
491873 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491873 | 257978 | TT.03.491873 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 4 (1)
491877 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491877 | 257978 | TT.03.491877 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 4 (1)
491940 | Půdorys 1.NP | 18 | 18 mm-18 mm | 491940 | 257978 | TT.03.491940 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | O2 (4bar) 4 (1)
491988 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491988 | 257978 | TT.03.491988 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 4 (1)
492255 | Půdorys 1.PP | 12 | 12 mm-12 mm | 492255 | 257978 | TT.02.492255 | Podlaží 1.NP | 2750 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
492378 | Půdorys 1.PP | 12 | 12 mm-12 mm | 492378 | 257978 | TT.02.492378 | Podlaží 1.NP | 2665 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
492380 | Půdorys 1.PP | 12 | 12 mm-12 mm | 492380 | 257978 | TT.02.492380 | Podlaží 1.NP | 2665 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
492382 | Půdorys 1.PP | 12 | 12 mm-12 mm | 492382 | 257978 | TT.02.492382 | Podlaží 1.NP | 2665 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 2
492424 | Půdorys 1.PP | 10 | 10 mm-10 mm | 492424 | 257978 | TT.02.492424 | Podlaží 1.NP | 2660 | O2 | 20.3 | 5 | 0.00000302733 | 11.2 | 7.1 | 4 | 0.6 |  | 13.2 | 5.6 | O2 (4bar) 2
492451 | Půdorys 1.PP | 12 | 12 mm-12 mm | 492451 | 257978 | TT.02.492451 | Podlaží 1.NP | 2660 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
492460 | Půdorys 1.PP | 12 | 12 mm-12 mm | 492460 | 257978 | TT.02.492460 | Podlaží 1.NP | 2660 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
492586 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492586 | 257978 | TT.02.492586 | Podlaží 1.NP | 2560 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | Vzduch (4bar) 3
492588 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492588 | 257978 | TT.02.492588 | Podlaží 1.NP | 2410 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | Vzduch (4bar) 3
492597 | Půdorys 1.PP | 18 | 18 mm-18 mm | 492597 | 257978 | TT.02.492597 | Podlaží 1.NP | 2560 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | O2 (4bar) 9
492599 | Půdorys 1.PP | 18 | 18 mm-18 mm | 492599 | 257978 | TT.02.492599 | Podlaží 1.NP | 2410 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | O2 (4bar) 9
492603 | Půdorys 1.PP | 18 | 18 mm-18 mm | 492603 | 257978 | TT.02.492603 | Podlaží 1.NP | 2410 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 9
492608 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492608 | 257978 | TT.02.492608 | Podlaží 1.NP | 2560 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | O2 (4bar) 1
492610 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492610 | 257978 | TT.02.492610 | Podlaží 1.NP | 2410 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | O2 (4bar) 1
492709 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492709 | 257978 | TT.02.492709 | Podlaží 1.NP | 2410 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | O2 (4bar) 1
492711 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492711 | 257978 | TT.02.492711 | Podlaží 1.NP | 2520 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | O2 (4bar) 1
492715 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492715 | 257978 | TT.02.492715 | Podlaží 1.NP | 2520 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | O2 (4bar) 1
492726 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492726 | 257978 | TT.02.492726 | Podlaží 1.NP | 2410 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | Vzduch (4bar) 3
492728 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492728 | 257978 | TT.02.492728 | Podlaží 1.NP | 2520 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | Vzduch (4bar) 3
492732 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492732 | 257978 | TT.02.492732 | Podlaží 1.NP | 2520 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | Vzduch (4bar) 3
492860 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492860 | 257978 | TT.02.492860 | Podlaží 1.NP | 2520 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | O2 (4bar) 1
492862 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492862 | 257978 | TT.02.492862 | Podlaží 1.NP | 2800 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | O2 (4bar) 1
492869 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492869 | 257978 | TT.02.492869 | Podlaží 1.NP | 2520 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | Vzduch (4bar) 3
492871 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492871 | 257978 | TT.02.492871 | Podlaží 1.NP | 2800 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | Vzduch (4bar) 3
492885 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492885 | 257978 | TT.02.492885 | Podlaží 1.NP | 2800 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | O2 (4bar) 1
492887 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492887 | 257978 | TT.02.492887 | Podlaží 1.NP | 2650 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | O2 (4bar) 1
492891 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492891 | 257978 | TT.02.492891 | Podlaží 1.NP | 2650 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | O2 (4bar) 1
492898 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492898 | 257978 | TT.02.492898 | Podlaží 1.NP | 2800 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | Vzduch (4bar) 3
492900 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492900 | 257978 | TT.02.492900 | Podlaží 1.NP | 2650 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | Vzduch (4bar) 3
492904 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492904 | 257978 | TT.02.492904 | Podlaží 1.NP | 2650 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | Vzduch (4bar) 3
492911 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492911 | 257978 | TT.02.492911 | Podlaží 1.NP | 2800 | Vakuum | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | Vakuum 1
492913 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492913 | 257978 | TT.02.492913 | Podlaží 1.NP | 2650 | Vakuum | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | Vakuum 1
492917 | Půdorys 1.PP | 28 | 28 mm-28 mm | 492917 | 257978 | TT.02.492917 | Podlaží 1.NP | 2650 | Vakuum | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | Vakuum 1
493139 | Půdorys 1.PP | 18 | 18 mm-18 mm | 493139 | 257978 | TT.02.493139 | Podlaží 1.NP | 2410 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 2
493188 | Půdorys 1.PP | 12 | 12 mm-12 mm | 493188 | 257978 | TT.02.493188 | Podlaží 1.NP | 2680 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 2
493190 | Půdorys 1.PP | 12 | 12 mm-12 mm | 493190 | 257978 | TT.02.493190 | Podlaží 1.NP | 2680 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
493226 | Půdorys 1.PP | 18 | 18 mm-18 mm | 493226 | 257978 | TT.02.493226 | Podlaží 1.NP | 2410 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | O2 (4bar) 2
493234 | Půdorys 1.PP | 12 | 12 mm-12 mm | 493234 | 257978 | TT.02.493234 | Podlaží 1.NP | 2665 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
493287 | Půdorys 1.PP | 12 | 12 mm-12 mm | 493287 | 257978 | TT.02.493287 | Podlaží 1.NP | 2750 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 2
493351 | Půdorys 1.PP | 12 | 12 mm-12 mm | 493351 | 257978 | TT.02.493351 | Podlaží 1.NP | 2560 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
493431 | Půdorys 1.PP | 12 | 12 mm-12 mm | 493431 | 257978 | TT.02.493431 | Podlaží 1.NP | 2750 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 2
493433 | Půdorys 1.PP | 12 | 12 mm-12 mm | 493433 | 257978 | TT.02.493433 | Podlaží 1.NP | 2750 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
493489 | Půdorys 1.PP | 12 | 12 mm-12 mm | 493489 | 257978 | TT.02.493489 | Podlaží 1.NP | 2750 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
493491 | Půdorys 1.PP | 12 | 12 mm-12 mm | 493491 | 257978 | TT.02.493491 | Podlaží 1.NP | 2750 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
493546 | Půdorys 1.PP | 12 | 12 mm-12 mm | 493546 | 257978 | TT.02.493546 | Podlaží 1.NP | 2750 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 2
493548 | Půdorys 1.PP | 12 | 12 mm-12 mm | 493548 | 257978 | TT.02.493548 | Podlaží 1.NP | 2750 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
518964 | Půdorys 1.PP | 12 | 12 mm-12 mm | 518964 | 257978 | TT.02.518964 | Podlaží 1.NP | 2560 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 2
518972 | Půdorys 1.PP | 12 | 12 mm-12 mm | 518972 | 257978 | TT.02.518972 | Podlaží 1.NP | 2660 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
518974 | Půdorys 1.PP | 12 | 12 mm-12 mm | 518974 | 257978 | TT.02.518974 | Podlaží 1.NP | 2660 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 2
519235 | Půdorys 1.PP | 12 | 12 mm-12 mm | 519235 | 257978 | TT.02.519235 | Podlaží 1.NP | 2750 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
519243 | Půdorys 1.PP | 12 | 12 mm-12 mm | 519243 | 257978 | TT.02.519243 | Podlaží 1.NP | 2560 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
519247 | Půdorys 1.PP | 12 | 12 mm-12 mm | 519247 | 257978 | TT.02.519247 | Podlaží 1.NP | 2560 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
519295 | Půdorys 1.PP | 12 | 12 mm-12 mm | 519295 | 257978 | TT.02.519295 | Podlaží 1.NP | 2665 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
519303 | Půdorys 1.PP | 12 | 12 mm-12 mm | 519303 | 257978 | TT.02.519303 | Podlaží 1.NP | 2560 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
519307 | Půdorys 1.PP | 12 | 12 mm-12 mm | 519307 | 257978 | TT.02.519307 | Podlaží 1.NP | 2560 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 2
521666 | Půdorys 1.PP | 28 | 28 mm-28 mm |  |  |  | Podlaží 1.PP | 2800 | Vakuum | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | Vakuum 1
521674 | Půdorys 1.PP | 28 | 28 mm-28 mm | 476309 | 257978 | TT.02.476309 | Podlaží 1.NP | 2950 | Vakuum | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | Vakuum 1
521676 | Půdorys 1.PP | 28 | 28 mm-28 mm |  |  |  | Podlaží 1.PP | 2950 | Vakuum | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 |  | 42.9 | 14.78 | Vakuum 1

# IfcFlowFitting: Redukce - pájení natvrdo - CU:Standard (64)
Type - Material: <Unnamed>
Type - NEMSOK - Výchozí výška: 0 mm; Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser; Tlakový stupeň: PN; Název typu: Standard; Označení typu: TT; Kategorie: Tvarovky; Lookup Table Name: Reducer Straight - Brazed - CU; Název rodiny: Redukce - pájení natvrdo - CU
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
NEMSOK - Tloušťka AllplanAttributes: 0 mm; CS_SCHEDULETYPEID: 257981; Podlaží: Podlaží 1.NP; Klasifikace systému: Ostatní; Jmenovitý tlak: 4 bar; Použít měřítko poznámky: no; Typ: Standard; Id typu: 257981; Rodina: Redukce - pájení natvrdo - CU; Rodina a typ: Redukce - pájení natvrdo - CU: Standard; Visibility 3: no
Name (Redukce - pájení natvrdo - CU:Standard:...) | In | Celková velikost = Velikost | CS_SCHEDULEID = ID | Kód prvku | Výška od podlaží (mm) | Fáze vytvoření | Teplonosná látka | Length (mm) | Maximální velikost (mm) = Max Průměr 12 (mm) | Průměr (mm) = Min Průměr 12 (mm) | Průměr 1 (mm) | Průměr 2 (mm) | Nominal Radius 1 (mm) | Nominal Radius 2 (mm) | Objem (m3) | Socket Outside Diameter 1 (mm) | Socket Outside Diameter 2 (mm) | Socket Width 1 (mm) | Socket Width 2 (mm) | Tick Size 1 (mm) | Tick Size 2 (mm) | Wall Thickness 1 (mm) | Wall Thickness 2 (mm) | Komentáře | Socket Outside Radius 1 (mm) | Socket Outside Radius 2 (mm) | Visibility 1 | Visibility 2 | Group
442261 | Půdorys 1.NP | 28 mm-22 mm | 442261 | TT.03.442261 | 1250 | Nová konstrukce | O2 | 35.42 | 28 | 22 | 28 | 22 | 14 | 11 | 0.0000197489 | 29.56 | 23.44 | 9.08 | 8.42 | 11.2 | 8.8 | 0.78 | 0.72 | Cu | 14.78 | 11.72 | yes | no | O2 (4bar) 1
442365 | Půdorys 1.NP | 28 mm-22 mm | 442365 | TT.03.442365 | 1250 | Nová konstrukce | Vakuum | 35.42 | 28 | 22 | 28 | 22 | 14 | 11 | 0.0000197489 | 29.56 | 23.44 | 9.08 | 8.42 | 11.2 | 8.8 | 0.78 | 0.72 | Cu | 14.78 | 11.72 | yes | no | Vakuum 1
442452 | Půdorys 1.NP | 28 mm-22 mm | 442452 | TT.03.442452 | 1250 | Nová konstrukce | Vzduch | 35.42 | 28 | 22 | 28 | 22 | 14 | 11 | 0.0000197489 | 29.56 | 23.44 | 9.08 | 8.42 | 11.2 | 8.8 | 0.78 | 0.72 | Cu | 14.78 | 11.72 | yes | no | Vzduch (4bar) 3
443393 | Půdorys 1.PP | 12 mm-10 mm | 443393 | TT.02.443393 | 1446.2 | Nová konstrukce | O2 | 30.78 | 12 | 10 | 10 | 12 | 5 | 6 | 0.00000361276 | 11.2 | 13.24 | 7.1 | 7.32 | 4 | 4.8 | 0.6 | 0.62 | Cu | 5.6 | 6.62 | no | yes | O2 (4bar) 2
443849 | Půdorys 1.PP | 12 mm-10 mm | 443849 | TT.02.443849 | 1476.98 | Nová konstrukce | O2 | 30.78 | 12 | 10 | 12 | 10 | 6 | 5 | 0.00000360574 | 13.24 | 11.2 | 7.32 | 7.1 | 4.8 | 4 | 0.62 | 0.6 | Cu | 6.62 | 5.6 | yes | no | O2 (4bar) 2
449557 | Půdorys 1.NP | 12 mm-10 mm | 449557 | TT.03.449557 | 2865 | Nová konstrukce | O2 | 30.78 | 12 | 10 | 10 | 12 | 5 | 6 | 0.00000361276 | 11.2 | 13.24 | 7.1 | 7.32 | 4 | 4.8 | 0.6 | 0.62 | Cu | 5.6 | 6.62 | no | yes | O2 (4bar) 4 (1)
449643 | Půdorys 1.NP | 12 mm-10 mm | 449643 | TT.03.449643 | 2865 | Nová konstrukce | O2 | 30.78 | 12 | 10 | 10 | 12 | 5 | 6 | 0.00000361276 | 11.2 | 13.24 | 7.1 | 7.32 | 4 | 4.8 | 0.6 | 0.62 | Cu | 5.6 | 6.62 | no | yes | O2 (4bar) 4 (1)
457026 | Půdorys 1.NP | 22 mm-12 mm | 457026 | TT.03.457026 | 1550 | Nová konstrukce | Vakuum | 36.98 | 22 | 12 | 22 | 12 | 11 | 6 | 0.0000103646 | 23.44 | 13.24 | 8.42 | 7.32 | 8.8 | 4.8 | 0.72 | 0.62 | Cu | 11.72 | 6.62 | yes | no | Vakuum 1
457101 | Půdorys 1.NP | 22 mm-12 mm | 457101 | TT.03.457101 | 1550 | Nová konstrukce | Vzduch | 36.98 | 22 | 12 | 22 | 12 | 11 | 6 | 0.0000103646 | 23.44 | 13.24 | 8.42 | 7.32 | 8.8 | 4.8 | 0.72 | 0.62 | Cu | 11.72 | 6.62 | yes | no | Vzduch (4bar) 3
457148 | Půdorys 1.NP | 22 mm-12 mm | 457148 | TT.03.457148 | 1550 | Nová konstrukce | O2 | 36.98 | 22 | 12 | 22 | 12 | 11 | 6 | 0.0000103646 | 23.44 | 13.24 | 8.42 | 7.32 | 8.8 | 4.8 | 0.72 | 0.62 | Cu | 11.72 | 6.62 | yes | no | O2 (4bar) 1
457814 | Půdorys 1.NP | 18 mm-12 mm | 457814 | TT.03.457814 | 2950 | Nová konstrukce | Vakuum | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 | Cu | 9.68 | 6.62 | yes | no | Vakuum 2
457822 | Půdorys 1.NP | 18 mm-12 mm | 457822 | TT.03.457822 | 2950 | Nová konstrukce | Vzduch | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 | Cu | 9.68 | 6.62 | yes | no | Vzduch (4bar) 4
457830 | Půdorys 1.NP | 18 mm-12 mm | 457830 | TT.03.457830 | 2950 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 | Cu | 9.68 | 6.62 | yes | no | O2 (4bar) 4 (1)
475200 | Půdorys 1.NP | 18 mm-12 mm | 475200 | TT.03.475200 | 2950 | Nová konstrukce | Vzduch | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 | Cu | 9.68 | 6.62 | yes | no | Vzduch (4bar) 2
476025 | Půdorys 1.NP | 10 mm-8 mm | 476025 | TT.03.476025 | 1446.2 | Nová konstrukce | O2 | 30.5 | 10 | 8 | 10 | 8 | 5 | 4 | 0.00000248411 | 11.2 | 9.16 | 7.1 | 6.88 | 4 | 3.2 | 0.6 | 0.58 | Cu | 5.6 | 4.58 | yes | no | O2 (4bar) 4 (1)
476036 | Půdorys 1.NP | 10 mm-8 mm | 476036 | TT.03.476036 | 1446.2 | Nová konstrukce | O2 | 30.5 | 10 | 8 | 10 | 8 | 5 | 4 | 0.00000248411 | 11.2 | 9.16 | 7.1 | 6.88 | 4 | 3.2 | 0.6 | 0.58 | Cu | 5.6 | 4.58 | yes | no | O2 (4bar) 4 (1)
476867 | Půdorys 1.PP | 28 mm-12 mm | 476867 | TT.02.476867 | 578.92 | Existující | Vzduch | 41.42 | 28 | 12 | 28 | 12 | 14 | 6 | 0.0000166141 | 29.56 | 13.24 | 9.08 | 7.32 | 11.2 | 4.8 | 0.78 | 0.62 | Cu | 14.78 | 6.62 | yes | no | Vzduch (4bar) 3
479085 | Půdorys 1.PP | 12 mm-10 mm | 479085 | TT.02.479085 | 1476.98 | Nová konstrukce | O2 | 30.78 | 12 | 10 | 12 | 10 | 6 | 5 | 0.00000360574 | 13.24 | 11.2 | 7.32 | 7.1 | 4.8 | 4 | 0.62 | 0.6 | Cu | 6.62 | 5.6 | yes | no | O2 (4bar) 2
479188 | Půdorys 1.PP | 12 mm-10 mm | 479188 | TT.02.479188 | 1476.98 | Nová konstrukce | O2 | 30.78 | 12 | 10 | 12 | 10 | 6 | 5 | 0.00000360574 | 13.24 | 11.2 | 7.32 | 7.1 | 4.8 | 4 | 0.62 | 0.6 | Cu | 6.62 | 5.6 | yes | no | O2 (4bar) 2
479315 | Půdorys 1.PP | 12 mm-10 mm | 479315 | TT.02.479315 | 1476.98 | Nová konstrukce | O2 | 30.78 | 12 | 10 | 12 | 10 | 6 | 5 | 0.00000360574 | 13.24 | 11.2 | 7.32 | 7.1 | 4.8 | 4 | 0.62 | 0.6 | Cu | 6.62 | 5.6 | yes | no | O2 (4bar) 2
480715 | Půdorys 1.PP | 28 mm-12 mm | 480715 | TT.02.480715 | 578.92 | Nová konstrukce | O2 | 41.42 | 28 | 12 | 28 | 12 | 14 | 6 | 0.0000166141 | 29.56 | 13.24 | 9.08 | 7.32 | 11.2 | 4.8 | 0.78 | 0.62 | Cu | 14.78 | 6.62 | yes | no | O2 (4bar) 1
481328 | Půdorys 1.PP | 28 mm-12 mm | 481328 | TT.02.481328 | 1700 | Nová konstrukce | O2 | 41.42 | 28 | 12 | 28 | 12 | 14 | 6 | 0.0000166141 | 29.56 | 13.24 | 9.08 | 7.32 | 11.2 | 4.8 | 0.78 | 0.62 | Cu | 14.78 | 6.62 | yes | no | O2 (4bar) 1
481451 | Půdorys 1.PP | 18 mm-12 mm | 481451 | TT.02.481451 | 1700 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 | Cu | 9.68 | 6.62 | yes | no | O2 (4bar) 9
481535 | Půdorys 1.PP | 28 mm-18 mm | 481535 | TT.02.481535 | 1394 | Nová konstrukce | O2 | 37.82 | 28 | 18 | 28 | 18 | 14 | 9 | 0.0000184267 | 29.56 | 19.36 | 9.08 | 7.98 | 11.2 | 7.2 | 0.78 | 0.68 | Cu | 14.78 | 9.68 | yes | no | O2 (4bar) 1
482180 | Půdorys 1.PP | 12 mm-10 mm | 482180 | TT.02.482180 | 1446.2 | Nová konstrukce | O2 | 30.78 | 12 | 10 | 10 | 12 | 5 | 6 | 0.00000361276 | 11.2 | 13.24 | 7.1 | 7.32 | 4 | 4.8 | 0.6 | 0.62 | Cu | 5.6 | 6.62 | no | yes | O2 (4bar) 2
485407 | Půdorys 1.PP | 28 mm-12 mm | 485407 | TT.02.485407 | 1700 | Nová konstrukce | Vzduch | 41.42 | 28 | 12 | 28 | 12 | 14 | 6 | 0.0000166141 | 29.56 | 13.24 | 9.08 | 7.32 | 11.2 | 4.8 | 0.78 | 0.62 | Cu | 14.78 | 6.62 | yes | no | Vzduch (4bar) 3
487286 | Půdorys 1.NP | 22 mm-18 mm | 487286 | TT.03.487286 | 2700 | Nová konstrukce | Vakuum | 33.38 | 22 | 18 | 18 | 22 | 9 | 11 | 0.0000120534 | 19.36 | 23.44 | 7.98 | 8.42 | 7.2 | 8.8 | 0.68 | 0.72 | Cu | 9.68 | 11.72 | no | yes | Vakuum 1
487384 | Půdorys 1.NP | 22 mm-18 mm | 487384 | TT.03.487384 | 2725.3 | Nová konstrukce | Vakuum | 33.38 | 22 | 18 | 22 | 18 | 11 | 9 | 0.0000120825 | 23.44 | 19.36 | 8.42 | 7.98 | 8.8 | 7.2 | 0.72 | 0.68 | Cu | 11.72 | 9.68 | yes | no | Vakuum 1
487474 | Půdorys 1.NP | 22 mm-18 mm | 487474 | TT.03.487474 | 2725.3 | Nová konstrukce | Vzduch | 33.38 | 22 | 18 | 22 | 18 | 11 | 9 | 0.0000120825 | 23.44 | 19.36 | 8.42 | 7.98 | 8.8 | 7.2 | 0.72 | 0.68 | Cu | 11.72 | 9.68 | yes | no | Vzduch (4bar) 3
487511 | Půdorys 1.NP | 22 mm-18 mm | 487511 | TT.03.487511 | 2700 | Nová konstrukce | Vzduch | 33.38 | 22 | 18 | 18 | 22 | 9 | 11 | 0.0000120534 | 19.36 | 23.44 | 7.98 | 8.42 | 7.2 | 8.8 | 0.68 | 0.72 | Cu | 9.68 | 11.72 | no | yes | Vzduch (4bar) 3
487569 | Půdorys 1.NP | 22 mm-18 mm | 487569 | TT.03.487569 | 2700 | Nová konstrukce | O2 | 33.38 | 22 | 18 | 18 | 22 | 9 | 11 | 0.0000120534 | 19.36 | 23.44 | 7.98 | 8.42 | 7.2 | 8.8 | 0.68 | 0.72 | Cu | 9.68 | 11.72 | no | yes | O2 (4bar) 1
487654 | Půdorys 1.NP | 22 mm-18 mm | 487654 | TT.03.487654 | 2725.3 | Nová konstrukce | O2 | 33.38 | 22 | 18 | 22 | 18 | 11 | 9 | 0.0000120825 | 23.44 | 19.36 | 8.42 | 7.98 | 8.8 | 7.2 | 0.72 | 0.68 | Cu | 11.72 | 9.68 | yes | no | O2 (4bar) 1
488574 | Půdorys 1.NP | 18 mm-12 mm | 488574 | TT.03.488574 | 2950 | Nová konstrukce | Vakuum | 34.02 | 18 | 12 | 12 | 18 | 6 | 9 | 0.00000728077 | 13.24 | 19.36 | 7.32 | 7.98 | 4.8 | 7.2 | 0.62 | 0.68 | Cu | 6.62 | 9.68 | no | yes | Vakuum 4
488581 | Půdorys 1.NP | 18 mm-12 mm | 488581 | TT.03.488581 | 2950 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 12 | 18 | 6 | 9 | 0.00000728077 | 13.24 | 19.36 | 7.32 | 7.98 | 4.8 | 7.2 | 0.62 | 0.68 | Cu | 6.62 | 9.68 | no | yes | O2 (4bar) 3
490867 | Půdorys 1.NP | 18 mm-12 mm | 490867 | TT.03.490867 | 3050 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 12 | 18 | 6 | 9 | 0.00000728077 | 13.24 | 19.36 | 7.32 | 7.98 | 4.8 | 7.2 | 0.62 | 0.68 |  | 6.62 | 9.68 | no | yes | O2 (4bar) 4 (1)
490871 | Půdorys 1.NP | 18 mm-12 mm | 490871 | TT.03.490871 | 3050 | Nová konstrukce | Vzduch | 34.02 | 18 | 12 | 12 | 18 | 6 | 9 | 0.00000728077 | 13.24 | 19.36 | 7.32 | 7.98 | 4.8 | 7.2 | 0.62 | 0.68 |  | 6.62 | 9.68 | no | yes | Vzduch (4bar) 4
490875 | Půdorys 1.NP | 18 mm-12 mm | 490875 | TT.03.490875 | 3050 | Nová konstrukce | Vakuum | 34.02 | 18 | 12 | 12 | 18 | 6 | 9 | 0.00000728077 | 13.24 | 19.36 | 7.32 | 7.98 | 4.8 | 7.2 | 0.62 | 0.68 |  | 6.62 | 9.68 | no | yes | Vakuum 2
490985 | Půdorys 1.NP | 18 mm-12 mm | 490985 | TT.03.490985 | 2927.1 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | O2 (4bar) 3
491026 | Půdorys 1.NP | 18 mm-12 mm | 491026 | TT.03.491026 | 2927.1 | Nová konstrukce | Vzduch | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | Vzduch (4bar) 2
491067 | Půdorys 1.NP | 18 mm-12 mm | 491067 | TT.03.491067 | 2927.1 | Nová konstrukce | Vakuum | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | Vakuum 4
491174 | Půdorys 1.NP | 18 mm-12 mm | 491174 | TT.03.491174 | 2927.1 | Nová konstrukce | Vakuum | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | Vakuum 4
491215 | Půdorys 1.NP | 18 mm-12 mm | 491215 | TT.03.491215 | 2927.1 | Nová konstrukce | Vzduch | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | Vzduch (4bar) 2
491256 | Půdorys 1.NP | 18 mm-12 mm | 491256 | TT.03.491256 | 2927.1 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | O2 (4bar) 3
491298 | Půdorys 1.NP | 18 mm-12 mm | 491298 | TT.03.491298 | 2927.1 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | O2 (4bar) 3
491339 | Půdorys 1.NP | 18 mm-12 mm | 491339 | TT.03.491339 | 2927.1 | Nová konstrukce | Vzduch | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | Vzduch (4bar) 2
491414 | Půdorys 1.NP | 18 mm-12 mm | 491414 | TT.03.491414 | 2927.1 | Nová konstrukce | Vakuum | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | Vakuum 4
491452 | Půdorys 1.NP | 18 mm-12 mm | 491452 | TT.03.491452 | 2927.1 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | O2 (4bar) 3
491493 | Půdorys 1.NP | 18 mm-12 mm | 491493 | TT.03.491493 | 2927.1 | Nová konstrukce | Vzduch | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | Vzduch (4bar) 2
491531 | Půdorys 1.NP | 18 mm-12 mm | 491531 | TT.03.491531 | 2927.1 | Nová konstrukce | Vakuum | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | Vakuum 4
491600 | Půdorys 1.NP | 18 mm-12 mm | 491600 | TT.03.491600 | 2927.1 | Nová konstrukce | Vakuum | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | Vakuum 2
491645 | Půdorys 1.NP | 18 mm-12 mm | 491645 | TT.03.491645 | 2927.1 | Nová konstrukce | Vzduch | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | Vzduch (4bar) 4
491686 | Půdorys 1.NP | 18 mm-12 mm | 491686 | TT.03.491686 | 2927.1 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | O2 (4bar) 4 (1)
491780 | Půdorys 1.NP | 18 mm-12 mm | 491780 | TT.03.491780 | 2927.1 | Nová konstrukce | Vakuum | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | Vakuum 2
491822 | Půdorys 1.NP | 18 mm-12 mm | 491822 | TT.03.491822 | 2927.1 | Nová konstrukce | Vzduch | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | Vzduch (4bar) 4
491867 | Půdorys 1.NP | 18 mm-12 mm | 491867 | TT.03.491867 | 2927.1 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | O2 (4bar) 4 (1)
491980 | Půdorys 1.NP | 18 mm-12 mm | 491980 | TT.03.491980 | 2927.1 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | O2 (4bar) 4 (1)
492427 | Půdorys 1.PP | 12 mm-10 mm | 492427 | TT.02.492427 | 2662.5 | Nová konstrukce | O2 | 30.78 | 12 | 10 | 10 | 12 | 5 | 6 | 0.00000361276 | 11.2 | 13.24 | 7.1 | 7.32 | 4 | 4.8 | 0.6 | 0.62 |  | 5.6 | 6.62 | no | yes | O2 (4bar) 2
493182 | Půdorys 1.PP | 18 mm-12 mm | 493182 | TT.02.493182 | 2432.9 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | O2 (4bar) 2
493228 | Půdorys 1.PP | 18 mm-12 mm | 493228 | TT.02.493228 | 2444.38 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | O2 (4bar) 2
493281 | Půdorys 1.PP | 18 mm-12 mm | 493281 | TT.02.493281 | 2432.9 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | O2 (4bar) 2
493343 | Půdorys 1.PP | 18 mm-12 mm | 493343 | TT.02.493343 | 2432.9 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | O2 (4bar) 2
493425 | Půdorys 1.PP | 18 mm-12 mm | 493425 | TT.02.493425 | 2432.9 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | O2 (4bar) 2
493483 | Půdorys 1.PP | 18 mm-12 mm | 493483 | TT.02.493483 | 2432.9 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | O2 (4bar) 2
493540 | Půdorys 1.PP | 18 mm-12 mm | 493540 | TT.02.493540 | 2432.9 | Nová konstrukce | O2 | 34.02 | 18 | 12 | 18 | 12 | 9 | 6 | 0.00000724864 | 19.36 | 13.24 | 7.98 | 7.32 | 7.2 | 4.8 | 0.68 | 0.62 |  | 9.68 | 6.62 | yes | no | O2 (4bar) 2

# IfcFlowFitting: T-kus - pájení natvrdo - CU:Standard (44)
Type - Material: <Unnamed>
Type - NEMSOK - Výchozí výška: 0 mm; Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee; Tlakový stupeň: PN; Název typu: Standard; Označení typu: TT; Kategorie: Tvarovky; Lookup Table Name: Tee - Brazed - CU; Název rodiny: T-kus - pájení natvrdo - CU
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
NEMSOK - Tloušťka AllplanAttributes: 0 mm; CS_SCHEDULETYPEID: 257983; Podlaží: Podlaží 1.NP; Fáze vytvoření: Nová konstrukce; Klasifikace systému: Ostatní; Jmenovitý tlak: 4 bar; Použít měřítko poznámky: no; Angle: 90 deg; Typ: Standard; Angle 1: 90 deg; Id typu: 257983; Rodina: T-kus - pájení natvrdo - CU; Rodina a typ: T-kus - pájení natvrdo - CU: Standard
Name (T-kus - pájení natvrdo - CU:Standard:...) | In | NominalDiameter = Fitting Outside Diameter (mm) = Maximální velikost (mm) = Průměr (mm) | Celková velikost = Velikost | CS_SCHEDULEID = ID | Kód prvku | Výška od podlaží (mm) | Teplonosná látka | Centre to End Branch (mm) = Length 4 (mm) | End to End Run (mm) | Nominal Radius (mm) = Fitting Outside Radius (mm) | Objem (m3) | Socket Outside Diameter (mm) | Socket Width (mm) | Tick Size (mm) | Wall Thickness (mm) | Centre to End Run (mm) = Length 3 (mm) = Length 5 (mm) | Length 1 (mm) = Length 2 (mm) | Socket Outside Radius (mm) | Group
442253 | Půdorys 1.NP | 28 | 28 mm-28 mm-28 mm | 442253 | TT.03.442253 | 1250 | O2 | 28.9 | 64 | 14 | 0.0000518051 | 29.56 | 9.08 | 11.2 | 0.78 | 32 | 19.82 | 14.78 | O2 (4bar) 1 | NEMSOK - Komentáře: Cu
442357 | Půdorys 1.NP | 28 | 28 mm-28 mm-28 mm | 442357 | TT.03.442357 | 1250 | Vakuum | 28.9 | 64 | 14 | 0.0000518051 | 29.56 | 9.08 | 11.2 | 0.78 | 32 | 19.82 | 14.78 | Vakuum 1 | NEMSOK - Komentáře: Cu
442444 | Půdorys 1.NP | 28 | 28 mm-28 mm-28 mm | 442444 | TT.03.442444 | 1250 | Vzduch | 28.9 | 64 | 14 | 0.0000518051 | 29.56 | 9.08 | 11.2 | 0.78 | 32 | 19.82 | 14.78 | Vzduch (4bar) 3 | NEMSOK - Komentáře: Cu
449654 | Půdorys 1.NP | 12 | 12 mm-12 mm-12 mm | 449654 | TT.03.449654 | 2865 | O2 | 19.3 | 44.8 | 6 | 0.00000721303 | 13.24 | 7.32 | 4.8 | 0.62 | 22.4 | 11.98 | 6.62 | O2 (4bar) 4 (1) | NEMSOK - Komentáře: Cu
457018 | Půdorys 1.NP | 22 | 22 mm-22 mm-22 mm | 457018 | TT.03.457018 | 1550 | Vakuum | 25.3 | 56.8 | 11 | 0.0000289566 | 23.44 | 8.42 | 8.8 | 0.72 | 28.4 | 16.88 | 11.72 | Vakuum 1 | NEMSOK - Komentáře: Cu
457093 | Půdorys 1.NP | 22 | 22 mm-22 mm-22 mm | 457093 | TT.03.457093 | 1550 | Vzduch | 25.3 | 56.8 | 11 | 0.0000289566 | 23.44 | 8.42 | 8.8 | 0.72 | 28.4 | 16.88 | 11.72 | Vzduch (4bar) 3 | NEMSOK - Komentáře: Cu
457140 | Půdorys 1.NP | 22 | 22 mm-22 mm-22 mm | 457140 | TT.03.457140 | 1550 | O2 | 25.3 | 56.8 | 11 | 0.0000289566 | 23.44 | 8.42 | 8.8 | 0.72 | 28.4 | 16.88 | 11.72 | O2 (4bar) 1 | NEMSOK - Komentáře: Cu
480766 | Půdorys 1.NP | 28 | 28 mm-28 mm-28 mm | 480766 | TT.02.480766 | -2300 | O2 | 28.9 | 64 | 14 | 0.0000518051 | 29.56 | 9.08 | 11.2 | 0.78 | 32 | 19.82 | 14.78 | O2 (4bar) 1 | NEMSOK - Komentáře: Cu
481320 | Půdorys 1.PP | 28 | 28 mm-28 mm-28 mm | 481320 | TT.02.481320 | 1700 | O2 | 28.9 | 64 | 14 | 0.0000518051 | 29.56 | 9.08 | 11.2 | 0.78 | 32 | 19.82 | 14.78 | O2 (4bar) 1 | NEMSOK - Komentáře: Cu
481422 | Půdorys 1.PP | 18 | 18 mm-18 mm-18 mm | 481422 | TT.02.481422 | 1700 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 9 | NEMSOK - Komentáře: Cu
481527 | Půdorys 1.PP | 28 | 28 mm-28 mm-28 mm | 481527 | TT.02.481527 | 1394 | O2 | 28.9 | 64 | 14 | 0.0000518051 | 29.56 | 9.08 | 11.2 | 0.78 | 32 | 19.82 | 14.78 | O2 (4bar) 1 | NEMSOK - Komentáře: Cu
485403 | Půdorys 1.PP | 28 | 28 mm-28 mm-28 mm | 485403 | TT.02.485403 | 1700 | Vzduch | 28.9 | 64 | 14 | 0.0000518051 | 29.56 | 9.08 | 11.2 | 0.78 | 32 | 19.82 | 14.78 | Vzduch (4bar) 3 | NEMSOK - Komentáře: Cu
485450 | Půdorys 1.PP | 28 | 28 mm-28 mm-28 mm | 485450 | TT.02.485450 | 1000 | Vzduch | 28.9 | 64 | 14 | 0.0000518051 | 29.56 | 9.08 | 11.2 | 0.78 | 32 | 19.82 | 14.78 | Vzduch (4bar) 3 | NEMSOK - Komentáře: Cu
487376 | Půdorys 1.NP | 22 | 22 mm-22 mm-22 mm | 487376 | TT.03.487376 | 2700 | Vakuum | 25.3 | 56.8 | 11 | 0.0000289566 | 23.44 | 8.42 | 8.8 | 0.72 | 28.4 | 16.88 | 11.72 | Vakuum 1 | NEMSOK - Komentáře: Cu
487466 | Půdorys 1.NP | 22 | 22 mm-22 mm-22 mm | 487466 | TT.03.487466 | 2700 | Vzduch | 25.3 | 56.8 | 11 | 0.0000289566 | 23.44 | 8.42 | 8.8 | 0.72 | 28.4 | 16.88 | 11.72 | Vzduch (4bar) 3 | NEMSOK - Komentáře: Cu
487646 | Půdorys 1.NP | 22 | 22 mm-22 mm-22 mm | 487646 | TT.03.487646 | 2700 | O2 | 25.3 | 56.8 | 11 | 0.0000289566 | 23.44 | 8.42 | 8.8 | 0.72 | 28.4 | 16.88 | 11.72 | O2 (4bar) 1 | NEMSOK - Komentáře: Cu
490639 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 490639 | TT.03.490639 | 3050 | Vakuum | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | Vakuum 2
490672 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 490672 | TT.03.490672 | 3050 | Vzduch | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | Vzduch (4bar) 4
490702 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 490702 | TT.03.490702 | 3050 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 4 (1)
490977 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 490977 | TT.03.490977 | 2950 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 3
491018 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491018 | TT.03.491018 | 2950 | Vzduch | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | Vzduch (4bar) 2
491059 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491059 | TT.03.491059 | 2950 | Vakuum | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | Vakuum 4
491166 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491166 | TT.03.491166 | 2950 | Vakuum | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | Vakuum 4
491207 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491207 | TT.03.491207 | 2950 | Vzduch | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | Vzduch (4bar) 2
491248 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491248 | TT.03.491248 | 2950 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 3
491290 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491290 | TT.03.491290 | 2950 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 3
491331 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491331 | TT.03.491331 | 2950 | Vzduch | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | Vzduch (4bar) 2
491406 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491406 | TT.03.491406 | 2950 | Vakuum | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | Vakuum 4
491444 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491444 | TT.03.491444 | 2950 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 3
491485 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491485 | TT.03.491485 | 2950 | Vzduch | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | Vzduch (4bar) 2
491523 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491523 | TT.03.491523 | 2950 | Vakuum | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | Vakuum 4
491592 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491592 | TT.03.491592 | 2950 | Vakuum | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | Vakuum 2
491637 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491637 | TT.03.491637 | 2950 | Vzduch | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | Vzduch (4bar) 4
491678 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491678 | TT.03.491678 | 2950 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 4 (1)
491772 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491772 | TT.03.491772 | 2950 | Vakuum | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | Vakuum 2
491814 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491814 | TT.03.491814 | 2950 | Vzduch | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | Vzduch (4bar) 4
491859 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491859 | TT.03.491859 | 2950 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 4 (1)
491972 | Půdorys 1.NP | 18 | 18 mm-18 mm-18 mm | 491972 | TT.03.491972 | 2950 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 4 (1)
493174 | Půdorys 1.PP | 18 | 18 mm-18 mm-18 mm | 493174 | TT.02.493174 | 2410 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 2
493273 | Půdorys 1.PP | 18 | 18 mm-18 mm-18 mm | 493273 | TT.02.493273 | 2410 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 2
493335 | Půdorys 1.PP | 18 | 18 mm-18 mm-18 mm | 493335 | TT.02.493335 | 2410 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 2
493417 | Půdorys 1.PP | 18 | 18 mm-18 mm-18 mm | 493417 | TT.02.493417 | 2410 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 2
493475 | Půdorys 1.PP | 18 | 18 mm-18 mm-18 mm | 493475 | TT.02.493475 | 2410 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 2
493532 | Půdorys 1.PP | 18 | 18 mm-18 mm-18 mm | 493532 | TT.02.493532 | 2410 | O2 | 22.9 | 52 | 9 | 0.0000180703 | 19.36 | 7.98 | 7.2 | 0.68 | 26 | 14.92 | 9.68 | O2 (4bar) 2

# IfcFlowSegment: Typy trubek:Měď - EN 13348 - pájení natvrdo (350)
Type - NEMSOK - Název typu: Měď - EN 13348 - pájení natvrdo; Označení typu: TR; Tlakový stupeň: PN; Kategorie: Trubky; Název rodiny: Typy trubek
Pset_DistributionFlowElementCommon - Reference: Měď - EN 13348 - pájení natvrdo; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
NEMSOK - Tloušťka AllplanAttributes: 0 mm; Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed; Klasifikace systému: Ostatní; Jmenovitý tlak: 4 bar; Typ přípoje: Obecné; Id typu: 432495; Rodina: Typy trubek; Rodina a typ: Typy trubek: Měď - EN 13348 - pájení natvrdo; Typ: Měď - EN 13348 - pájení natvrdo
Name (Typy trubek:Měď - EN 13348 - pájení natvrdo:...) | In | Length (mm) = Délka (mm) | Celková velikost = Velikost | Výška dolní hrany AllplanAttributes dole (mm) = Výška dolní hrany dole (mm) | Výška dolní hrany AllplanAttributes nahoře (mm) = Výška dolní hrany nahoře (mm) | Výška horní hrany AllplanAttributes dole (mm) = Výška horní hrany dole (mm) | Výška horní hrany AllplanAttributes nahoře (mm) = Výška horní hrany nahoře (mm) | CS_SCHEDULEID = ID | CS_SCHEDULETYPEID | Relativní drsnost | Kód prvku | Podlaží | Koncová výška osy (mm) | Počáteční výška osy (mm) = Výška osy (mm) | Referenční podlaží | Sklon | Výška dna trubky dole (mm) | Výška dna trubky nahoře (mm) | Výška osy dole (mm) | Výška osy nahoře (mm) | Výška stropu trubky dole (mm) | Výška stropu trubky nahoře (mm) | Fáze vytvoření | Drsnost (mm) | Materiál | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) = Vnější průměr (mm) | Řez | Teplonosná látka | Úsek potrubí | Výkaz/typ | Tloustka (mm) | Vnitřní průměr (mm) | Komentáře | Group
438700 | Půdorys 1.NP | 4.26 | 22 mm | 1239 | 1239 | 1261 | 1261 | 438700 | 432495 | 0.000127 | TR.03.438700 | Podlaží 1.NP | 1250 | 1250 | Podlaží 1.NP | 0 | 1240 | 1240 | 1250 | 1250 | 1260 | 1260 | Nová konstrukce | 0.00254 | Kov - Měď | 1240 | 0.00029443 | 22 | 23 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | O2 (4bar) 1
438741 | Půdorys 1.NP | 68.58 | 22 mm | 1291.42 | 1360 | 1291.42 | 1360 | 438741 | 432495 | 0.000127 | TR.03.438741 | Podlaží 1.NP | 1291.42 | 1360 | Podlaží 1.NP |  | 1291.42 | 1360 | 1291.42 | 1360 | 1291.42 | 1360 | Nová konstrukce | 0.00254 | Kov - Měď | 1291.42 | 0.00473991 | 22 | 23 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | O2 (4bar) 1
438784 | Půdorys 1.NP | 4.26 | 22 mm | 1239 | 1239 | 1261 | 1261 | 438784 | 432495 | 0.000127 | TR.03.438784 | Podlaží 1.NP | 1250 | 1250 | Podlaží 1.NP | 0 | 1240 | 1240 | 1250 | 1250 | 1260 | 1260 | Nová konstrukce | 0.00254 | Kov - Měď | 1240 | 0.00029443 | 22 | 12 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vzduch (4bar) 3
438824 | Půdorys 1.NP | 68.58 | 22 mm | 1291.42 | 1360 | 1291.42 | 1360 | 438824 | 432495 | 0.000127 | TR.03.438824 | Podlaží 1.NP | 1291.42 | 1360 | Podlaží 1.NP |  | 1291.42 | 1360 | 1291.42 | 1360 | 1291.42 | 1360 | Nová konstrukce | 0.00254 | Kov - Měď | 1291.42 | 0.00473991 | 22 | 12 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vzduch (4bar) 3
438835 | Půdorys 1.NP | 4.26 | 22 mm | 1239 | 1239 | 1261 | 1261 | 438835 | 432495 | 0.000127 | TR.03.438835 | Podlaží 1.NP | 1250 | 1250 | Podlaží 1.NP | 0 | 1240 | 1240 | 1250 | 1250 | 1260 | 1260 | Nová konstrukce | 0.00254 | Kov - Měď | 1240 | 0.00029443 | 22 | 23 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vakuum 1
438868 | Půdorys 1.NP | 68.58 | 22 mm | 1291.42 | 1360 | 1291.42 | 1360 | 438868 | 432495 | 0.000127 | TR.03.438868 | Podlaží 1.NP | 1291.42 | 1360 | Podlaží 1.NP |  | 1291.42 | 1360 | 1291.42 | 1360 | 1291.42 | 1360 | Nová konstrukce | 0.00254 | Kov - Měď | 1291.42 | 0.00473991 | 22 | 23 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vakuum 1
438973 | Půdorys 1.NP | 17.16 | 22 mm | 2689 | 2689 | 2711 | 2711 | 438973 | 432495 | 0.000127 | TR.03.438973 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2690 | 2690 | 2700 | 2700 | 2710 | 2710 | Nová konstrukce | 0.00254 | Kov - Měď | 2690 | 0.00118601 | 22 | 40 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vakuum 1
439028 | Půdorys 1.NP | 9152.16 | 22 mm | 2689 | 2689 | 2711 | 2711 | 439028 | 432495 | 0.000127 | TR.03.439028 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2690 | 2690 | 2700 | 2700 | 2710 | 2710 | Nová konstrukce | 0.00254 | Kov - Měď | 2690 | 0.632552 | 22 | 40 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vakuum 1
439047 | Půdorys 1.NP | 17.16 | 22 mm | 2689 | 2689 | 2711 | 2711 | 439047 | 432495 | 0.000127 | TR.03.439047 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2690 | 2690 | 2700 | 2700 | 2710 | 2710 | Nová konstrukce | 0.00254 | Kov - Měď | 2690 | 0.00118601 | 22 | 22 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vzduch (4bar) 3
439060 | Půdorys 1.NP | 9077.16 | 22 mm | 2689 | 2689 | 2711 | 2711 | 439060 | 432495 | 0.000127 | TR.03.439060 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2690 | 2690 | 2700 | 2700 | 2710 | 2710 | Nová konstrukce | 0.00254 | Kov - Měď | 2690 | 0.627368 | 22 | 22 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vzduch (4bar) 3
439081 | Půdorys 1.NP | 17.16 | 22 mm | 2689 | 2689 | 2711 | 2711 | 439081 | 432495 | 0.000127 | TR.03.439081 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2690 | 2690 | 2700 | 2700 | 2710 | 2710 | Nová konstrukce | 0.00254 | Kov - Měď | 2690 | 0.00118601 | 22 | 59 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | O2 (4bar) 1
439094 | Půdorys 1.NP | 9002.16 | 22 mm | 2689 | 2689 | 2711 | 2711 | 439094 | 432495 | 0.000127 | TR.03.439094 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2690 | 2690 | 2700 | 2700 | 2710 | 2710 | Nová konstrukce | 0.00254 | Kov - Měď | 2690 | 0.622185 | 22 | 59 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | O2 (4bar) 1
442254 | Půdorys 1.PP | 418 | 28 mm | 4582 | 5000 | 4582 | 5000 | 442254 | 432495 | 0.0001016 | TR.03.442254 | Podlaží 1.NP | 4582 | 5000 | Podlaží 1.PP |  | 4582 | 5000 | 4582 | 5000 | 4582 | 5000 | Nová konstrukce | 0.00254 | Kov - Měď | 1282 | 0.0367692 | 28 | 13 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
442358 | Půdorys 1.PP | 418 | 28 mm | 4582 | 5000 | 4582 | 5000 | 442358 | 432495 | 0.0001016 | TR.03.442358 | Podlaží 1.NP | 4582 | 5000 | Podlaží 1.PP |  | 4582 | 5000 | 4582 | 5000 | 4582 | 5000 | Nová konstrukce | 0.00254 | Kov - Měď | 1282 | 0.0367692 | 28 | 11 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vakuum 1
442431 | Půdorys 1.PP | 1816.02 | 28 mm | 2701.98 | 4518 | 2701.98 | 4518 | 442431 | 432495 | 0.0001016 | TR.02.442431 | Podlaží 1.NP | 2701.98 | 4518 | Podlaží 1.PP |  | 2701.98 | 4518 | 2701.98 | 4518 | 2701.98 | 4518 | Nová konstrukce | 0.00254 | Kov - Měď | -598.02 | 0.159745 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
442445 | Půdorys 1.PP | 418 | 28 mm | 4582 | 5000 | 4582 | 5000 | 442445 | 432495 | 0.0001016 | TR.03.442445 | Podlaží 1.NP | 4582 | 5000 | Podlaží 1.PP |  | 4582 | 5000 | 4582 | 5000 | 4582 | 5000 | Nová konstrukce | 0.00254 | Kov - Měď | 1282 | 0.0367692 | 28 | 8 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
442620 | Půdorys 1.PP | 12546 | 28 mm | 2786 | 2786 | 2814 | 2814 | 442620 | 432495 | 0.0001016 | TR.02.442620 | Podlaží 1.NP | 2800 | 2800 | Podlaží 1.PP | 0 | 2787.5 | 2787.5 | 2800 | 2800 | 2812.5 | 2812.5 | Nová konstrukce | 0.00254 | Kov - Měď | -512.5 | 1.10361 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
442632 | Půdorys 1.PP | 8357.17 | 28 mm | 2936 | 2936 | 2964 | 2964 | 442632 | 432495 | 0.0001016 | TR.02.442632 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.PP | 0 | 2937.5 | 2937.5 | 2950 | 2950 | 2962.5 | 2962.5 | Nová konstrukce | 0.00254 | Kov - Měď | -362.5 | 0.735135 | 28 | 42 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vakuum 1
442784 | Půdorys 1.PP | 111.24 | 18 mm | 2401 | 2401 | 2419 | 2419 | 442784 | 432495 | 0.00015875 | TR.02.442784 | Podlaží 1.NP | 2410 | 2410 | Podlaží 1.PP | 0 | 2402 | 2402 | 2410 | 2410 | 2418 | 2418 | Nová konstrukce | 0.00254 | Kov - Měď | -898 | 0.00629047 | 18 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 9
442794 | Půdorys 1.PP | 475.62 | 18 mm | 1900 | 2375.62 | 1900 | 2375.62 | 442794 | 432495 | 0.00015875 | TR.02.442794 | Podlaží 1.NP | 2375.62 | 1900 | Podlaží 1.PP |  | 1900 | 2375.62 | 1900 | 2375.62 | 1900 | 2375.62 | Nová konstrukce | 0.00254 | Kov - Měď | -1400 | 0.0268957 | 18 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 1; O2 (4bar) 9
442817 | Půdorys 1.PP | 111.24 | 18 mm | 2401 | 2401 | 2419 | 2419 | 442817 | 432495 | 0.00015875 | TR.02.442817 | Podlaží 1.NP | 2410 | 2410 | Podlaží 1.PP | 0 | 2402 | 2402 | 2410 | 2410 | 2418 | 2418 | Nová konstrukce | 0.00254 | Kov - Měď | -898 | 0.00629047 | 18 | 27 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 2
442827 | Půdorys 1.PP | 475.62 | 18 mm | 1900 | 2375.62 | 1900 | 2375.62 | 442827 | 432495 | 0 | TR.02.442827 | Podlaží 1.NP | 2375.62 | 1900 | Podlaží 1.PP |  | 1900 | 2375.62 | 1900 | 2375.62 | 1900 | 2375.62 | Nová konstrukce | 0.00254 | Kov - Měď | -1400 | 0.0268957 | 18 | 27 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 2
443181 | Půdorys 1.PP | 909.713 | 12 mm | 2674 | 2674 | 2686 | 2686 | 443181 | 432495 | 0.000254 | TR.02.443181 | Podlaží 1.NP | 2680 | 2680 | Podlaží 1.PP | 0 | 2675 | 2675 | 2680 | 2680 | 2685 | 2685 | Nová konstrukce | 0.00254 | Kov - Měď | -625 | 0.0342954 | 12 | 3 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
443183 | Půdorys 1.PP | 1179.2 | 12 mm | 1476.98 | 2656.18 | 1476.98 | 2656.18 | 443183 | 432495 | 0 | TR.02.443183 | Podlaží 1.NP | 1476.98 | 2656.18 | Podlaží 1.PP |  | 1476.98 | 2656.18 | 1476.98 | 2656.18 | 1476.98 | 2656.18 | Nová konstrukce | 0.00254 | Kov - Měď | -1823.02 | 0.0444548 | 12 | 3 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
443193 | Půdorys 1.PP | 4228.71 | 12 mm | 2674 | 2674 | 2686 | 2686 | 443193 | 432495 | 0.000254 | TR.02.443193 | Podlaží 1.NP | 2680 | 2680 | Podlaží 1.PP | 0 | 2675 | 2675 | 2680 | 2680 | 2685 | 2685 | Nová konstrukce | 0.00254 | Kov - Měď | -625 | 0.159419 | 12 | 3 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
443376 | Půdorys 1.PP | 2533.46 | 12 mm | 2659 | 2659 | 2671 | 2671 | 443376 | 432495 | 0.000254 | TR.02.443376 | Podlaží 1.NP | 2665 | 2665 | Podlaží 1.PP | 0 | 2660 | 2660 | 2665 | 2665 | 2670 | 2670 | Nová konstrukce | 0.00254 | Kov - Měď | -640 | 0.0955091 | 12 | 6 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
443378 | Půdorys 1.PP | 1164.2 | 12 mm | 1476.98 | 2641.18 | 1476.98 | 2641.18 | 443378 | 432495 | 0 | TR.02.443378 | Podlaží 1.NP | 2641.18 | 1476.98 | Podlaží 1.PP |  | 1476.98 | 2641.18 | 1476.98 | 2641.18 | 1476.98 | 2641.18 | Nová konstrukce | 0.00254 | Kov - Měď | -1823.02 | 0.0438893 | 12 | 6 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
443397 | Půdorys 1.PP | 3146.17 | 12 mm | 2659 | 2659 | 2671 | 2671 | 443397 | 432495 | 0.000254 | TR.02.443397 | Podlaží 1.NP | 2665 | 2665 | Podlaží 1.PP | 0 | 2660 | 2660 | 2665 | 2665 | 2670 | 2670 | Nová konstrukce | 0.00254 | Kov - Měď | -640 | 0.118608 | 12 | 6 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
443976 | Půdorys 1.PP | 1816.02 | 28 mm | 2701.98 | 4518 | 2701.98 | 4518 | 443976 | 432495 | 0.0001016 | TR.02.443976 | Podlaží 1.NP | 2701.98 | 4518 | Podlaží 1.PP |  | 2701.98 | 4518 | 2701.98 | 4518 | 2701.98 | 4518 | Nová konstrukce | 0.00254 | Kov - Měď | -598.02 | 0.159745 | 28 | 42 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vakuum 1
444700 | Půdorys 1.NP | 718.683 | 22 mm | 2689 | 2689 | 2711 | 2711 | 444700 | 432495 | 0.000127 | TR.03.444700 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2690 | 2690 | 2700 | 2700 | 2710 | 2710 | Nová konstrukce | 0.00254 | Kov - Měď | 2690 | 0.0496718 | 22 | 59 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | O2 (4bar) 1
444848 | Půdorys 1.NP | 309.84 | 22 mm | 2689 | 2689 | 2711 | 2711 | 444848 | 432495 | 0.000127 | TR.03.444848 | Podlaží 1.NP | 2700 | 2700 | Podlaží 1.NP | 0 | 2690 | 2690 | 2700 | 2700 | 2710 | 2710 | Nová konstrukce | 0.00254 | Kov - Měď | 2690 | 0.0214146 | 22 | 57 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vzduch (4bar) 3
446613 | Půdorys 1.NP | 11451.3 | 18 mm | 2941 | 2941 | 2959 | 2959 | 446613 | 432495 | 0.00015875 | TR.03.446613 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.647557 | 18 | 1 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 3
446845 | Půdorys 1.NP | 11451.3 | 18 mm | 2941 | 2941 | 2959 | 2959 | 446845 | 432495 | 0.00015875 | TR.03.446845 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.647557 | 18 | 1 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 2
446858 | Půdorys 1.NP | 11451.3 | 18 mm | 2941 | 2941 | 2959 | 2959 | 446858 | 432495 | 0.00015875 | TR.03.446858 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.647557 | 18 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 4
446937 | Půdorys 1.NP | 1552.34 | 18 mm | 2941 | 2941 | 2959 | 2959 | 446937 | 432495 | 0.00015875 | TR.03.446937 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0877826 | 18 | 75 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 4 (1)
446939 | Půdorys 1.NP | 11451.3 | 18 mm | 2941 | 2941 | 2959 | 2959 | 446939 | 432495 | 0.00015875 | TR.03.446939 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.647557 | 18 | 1 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 4
446941 | Půdorys 1.NP | 11451.3 | 18 mm | 2941 | 2941 | 2959 | 2959 | 446941 | 432495 | 0.00015875 | TR.03.446941 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.647557 | 18 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 2
447659 | Půdorys 1.NP | 1344.06 | 18 mm | 2941 | 2941 | 2959 | 2959 | 447659 | 432495 | 0.00015875 | TR.03.447659 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.0760051 | 18 | 13 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 2
449542 | Půdorys 1.NP | 177.928 | 12 mm | 2859 | 2859 | 2871 | 2871 | 449542 | 432495 | 0.000254 | TR.03.449542 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.00670772 | 12 | 68 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
449552 | Půdorys 1.NP | 1371.52 | 8 mm | 1476.7 | 2848.22 | 1476.7 | 2848.22 | 449552 | 432495 | 0.000423333 | TR.03.449552 | Podlaží 1.NP | 2848.22 | 1476.7 | Podlaží 1.NP |  | 1476.7 | 2848.22 | 1476.7 | 2848.22 | 1476.7 | 2848.22 | Nová konstrukce | 0.00254 | Kov - Měď | 1476.7 | 0.0344701 | 8 | 43 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 6 | Cu | O2 (4bar) 4 (1)
449560 | Půdorys 1.NP | 11503.8 | 12 mm | 2859 | 2859 | 2871 | 2871 | 449560 | 432495 | 0.000254 | TR.03.449560 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.433682 | 12 | 48 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
