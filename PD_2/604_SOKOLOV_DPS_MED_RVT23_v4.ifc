Properties of the parts of a building model (IFC2X3), part 2 of 5

# IfcDistributionPort (1553)
Name | FlowDirection | Group
Port_491569_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_488512_0 | SOURCEANDSINK | Vakuum 2
Port_491592_1 | SOURCEANDSINK | Vakuum 2
Port_488512_1 | SOURCEANDSINK | Vakuum 2
Port_491573_2 | SOURCEANDSINK | Vakuum 2
Port_488572_1 | SOURCEANDSINK | Vakuum 4
Port_488574_2 | SOURCEANDSINK | Vakuum 4
Port_488572_2 | SOURCEANDSINK | Vakuum 4
Port_491167_0 | SOURCEANDSINK | Vakuum 4
Port_488579_1 | SOURCEANDSINK | O2 (4bar) 3
Port_488581_2 | SOURCEANDSINK | O2 (4bar) 3
Port_488579_2 | SOURCEANDSINK | O2 (4bar) 3
Port_491249_0 | SOURCEANDSINK | O2 (4bar) 3
Port_489008_0 | SOURCEANDSINK | Vakuum 4
Port_491166_1 | SOURCEANDSINK | Vakuum 4
Port_489008_1 | SOURCEANDSINK | Vakuum 4
Port_491142_2 | SOURCEANDSINK | Vakuum 4
Port_489091_0 | SOURCEANDSINK | O2 (4bar) 3
Port_491248_1 | SOURCEANDSINK | O2 (4bar) 3
Port_489091_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491138_2 | SOURCEANDSINK | O2 (4bar) 3
Port_489590_0 | SOURCEANDSINK | O2 (4bar) 3
Port_489857_2 | SOURCEANDSINK | O2 (4bar) 3
Port_489590_1 | SOURCEANDSINK | O2 (4bar) 3
Port_490720_1 | SOURCEANDSINK | O2 (4bar) 3
Port_489592_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_489853_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_489592_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_490722_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_489594_0 | SOURCEANDSINK | Vakuum 4
Port_489849_2 | SOURCEANDSINK | Vakuum 4
Port_489594_1 | SOURCEANDSINK | Vakuum 4
Port_490724_1 | SOURCEANDSINK | Vakuum 4
Port_489596_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490710_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_489596_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490712_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_489598_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490680_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_489598_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490682_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_489600_0 | SOURCEANDSINK | Vakuum 2
Port_490647_2 | SOURCEANDSINK | Vakuum 2
Port_489600_1 | SOURCEANDSINK | Vakuum 2
Port_490649_2 | SOURCEANDSINK | Vakuum 2
Port_489687_0 | SOURCEANDSINK | O2 (4bar) 3
Port_489855_1 | SOURCEANDSINK | O2 (4bar) 3
Port_489687_1 | SOURCEANDSINK | O2 (4bar) 3
Port_489857_1 | SOURCEANDSINK | O2 (4bar) 3
Port_489750_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_489851_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_489750_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_489853_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_489766_0 | SOURCEANDSINK | Vakuum 4
Port_489847_1 | SOURCEANDSINK | Vakuum 4
Port_489766_1 | SOURCEANDSINK | Vakuum 4
Port_489849_1 | SOURCEANDSINK | Vakuum 4
Port_489774_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491940_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_489774_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490710_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_489782_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_489839_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_489782_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490680_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_489790_0 | SOURCEANDSINK | Vakuum 2
Port_489835_1 | SOURCEANDSINK | Vakuum 2
Port_489790_1 | SOURCEANDSINK | Vakuum 2
Port_490647_1 | SOURCEANDSINK | Vakuum 2
Port_489902_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_489960_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_489902_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_489962_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_489929_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_489955_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_489929_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_489962_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490102_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490867_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490102_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490702_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490104_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490871_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490104_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490672_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490106_0 | SOURCEANDSINK | Vakuum 2
Port_490875_2 | SOURCEANDSINK | Vakuum 2
Port_490106_1 | SOURCEANDSINK | Vakuum 2
Port_490639_1 | SOURCEANDSINK | Vakuum 2
Port_490543_0 | SOURCEANDSINK | Vakuum 2
Port_491573_1 | SOURCEANDSINK | Vakuum 2
Port_490543_1 | SOURCEANDSINK | Vakuum 2
Port_490549_1 | SOURCEANDSINK | Vakuum 2
Port_490549_2 | SOURCEANDSINK | Vakuum 2
Port_490640_0 | SOURCEANDSINK | Vakuum 2
Port_490575_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491569_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490575_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490581_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490581_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490673_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490604_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491565_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490604_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490610_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490610_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490703_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490637_0 | SOURCEANDSINK | Vakuum 2
Port_490639_3 | SOURCEANDSINK | Vakuum 2
Port_490637_1 | SOURCEANDSINK | Vakuum 2
Port_490649_1 | SOURCEANDSINK | Vakuum 2
Port_490639_2 | SOURCEANDSINK | Vakuum 2
Port_490640_1 | SOURCEANDSINK | Vakuum 2
Port_490670_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490672_3 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490670_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490682_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490672_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490673_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490700_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490702_3 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490700_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490712_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490702_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490703_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490720_2 | SOURCEANDSINK | O2 (4bar) 3
Port_490978_0 | SOURCEANDSINK | O2 (4bar) 3
Port_490722_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491019_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_490724_2 | SOURCEANDSINK | Vakuum 4
Port_491060_0 | SOURCEANDSINK | Vakuum 4
Port_490865_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490867_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_490869_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490871_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_490873_2 | SOURCEANDSINK | Vakuum 2
Port_490875_1 | SOURCEANDSINK | Vakuum 2
Port_490975_0 | SOURCEANDSINK | O2 (4bar) 3
Port_490985_2 | SOURCEANDSINK | O2 (4bar) 3
Port_490975_1 | SOURCEANDSINK | O2 (4bar) 3
Port_490995_1 | SOURCEANDSINK | O2 (4bar) 3
Port_490977_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491445_0 | SOURCEANDSINK | O2 (4bar) 3
Port_490977_2 | SOURCEANDSINK | O2 (4bar) 3
Port_490978_1 | SOURCEANDSINK | O2 (4bar) 3
Port_490977_3 | SOURCEANDSINK | O2 (4bar) 3
Port_490985_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491016_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491026_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491016_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491036_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491018_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491486_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491018_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491019_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491018_3 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491026_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491057_0 | SOURCEANDSINK | Vakuum 4
Port_491067_2 | SOURCEANDSINK | Vakuum 4
Port_491057_1 | SOURCEANDSINK | Vakuum 4
Port_491077_1 | SOURCEANDSINK | Vakuum 4
Port_491059_1 | SOURCEANDSINK | Vakuum 4
Port_491524_0 | SOURCEANDSINK | Vakuum 4
Port_491059_2 | SOURCEANDSINK | Vakuum 4
Port_491060_1 | SOURCEANDSINK | Vakuum 4
Port_491059_3 | SOURCEANDSINK | Vakuum 4
Port_491067_1 | SOURCEANDSINK | Vakuum 4
Port_491164_0 | SOURCEANDSINK | Vakuum 4
Port_491174_2 | SOURCEANDSINK | Vakuum 4
Port_491164_1 | SOURCEANDSINK | Vakuum 4
Port_491184_1 | SOURCEANDSINK | Vakuum 4
Port_491166_2 | SOURCEANDSINK | Vakuum 4
Port_491167_1 | SOURCEANDSINK | Vakuum 4
Port_491166_3 | SOURCEANDSINK | Vakuum 4
Port_491174_1 | SOURCEANDSINK | Vakuum 4
Port_491205_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491215_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491205_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491225_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491207_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491208_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491207_3 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491215_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491246_0 | SOURCEANDSINK | O2 (4bar) 3
Port_491256_2 | SOURCEANDSINK | O2 (4bar) 3
Port_491246_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491266_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491248_2 | SOURCEANDSINK | O2 (4bar) 3
Port_491249_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491248_3 | SOURCEANDSINK | O2 (4bar) 3
Port_491256_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491288_0 | SOURCEANDSINK | O2 (4bar) 3
Port_491298_2 | SOURCEANDSINK | O2 (4bar) 3
Port_491288_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491308_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491290_2 | SOURCEANDSINK | O2 (4bar) 3
Port_491291_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491290_3 | SOURCEANDSINK | O2 (4bar) 3
Port_491298_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491291_0 | SOURCEANDSINK | O2 (4bar) 3
Port_491444_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491329_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491339_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491329_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491349_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491331_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491332_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491331_3 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491339_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491332_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491485_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491404_0 | SOURCEANDSINK | Vakuum 4
Port_491414_2 | SOURCEANDSINK | Vakuum 4
Port_491404_1 | SOURCEANDSINK | Vakuum 4
Port_491424_1 | SOURCEANDSINK | Vakuum 4
Port_491406_2 | SOURCEANDSINK | Vakuum 4
Port_491407_1 | SOURCEANDSINK | Vakuum 4
Port_491406_3 | SOURCEANDSINK | Vakuum 4
Port_491414_1 | SOURCEANDSINK | Vakuum 4
Port_491407_0 | SOURCEANDSINK | Vakuum 4
Port_491523_1 | SOURCEANDSINK | Vakuum 4
Port_491442_0 | SOURCEANDSINK | O2 (4bar) 3
Port_491452_2 | SOURCEANDSINK | O2 (4bar) 3
Port_491442_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491462_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491444_2 | SOURCEANDSINK | O2 (4bar) 3
Port_491445_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491444_3 | SOURCEANDSINK | O2 (4bar) 3
Port_491452_1 | SOURCEANDSINK | O2 (4bar) 3
Port_491483_0 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491493_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491483_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491503_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491485_2 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491486_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491485_3 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491493_1 | SOURCEANDSINK | Vzduch (4bar) 2
Port_491521_0 | SOURCEANDSINK | Vakuum 4
Port_491531_2 | SOURCEANDSINK | Vakuum 4
Port_491521_1 | SOURCEANDSINK | Vakuum 4
Port_491541_1 | SOURCEANDSINK | Vakuum 4
Port_491523_2 | SOURCEANDSINK | Vakuum 4
Port_491524_1 | SOURCEANDSINK | Vakuum 4
Port_491523_3 | SOURCEANDSINK | Vakuum 4
Port_491531_1 | SOURCEANDSINK | Vakuum 4
Port_491590_0 | SOURCEANDSINK | Vakuum 2
Port_491600_2 | SOURCEANDSINK | Vakuum 2
Port_491590_1 | SOURCEANDSINK | Vakuum 2
Port_491610_1 | SOURCEANDSINK | Vakuum 2
Port_491592_2 | SOURCEANDSINK | Vakuum 2
Port_491593_1 | SOURCEANDSINK | Vakuum 2
Port_491592_3 | SOURCEANDSINK | Vakuum 2
Port_491600_1 | SOURCEANDSINK | Vakuum 2
Port_491593_0 | SOURCEANDSINK | Vakuum 2
Port_491772_1 | SOURCEANDSINK | Vakuum 2
Port_491635_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491645_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491635_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491655_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491637_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491638_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491637_3 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491645_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491638_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491814_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491676_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491686_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491676_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491696_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491678_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491679_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491678_3 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491686_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491679_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491859_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491770_0 | SOURCEANDSINK | Vakuum 2
Port_491780_2 | SOURCEANDSINK | Vakuum 2
Port_491770_1 | SOURCEANDSINK | Vakuum 2
Port_491790_1 | SOURCEANDSINK | Vakuum 2
Port_491772_2 | SOURCEANDSINK | Vakuum 2
Port_491773_1 | SOURCEANDSINK | Vakuum 2
Port_491772_3 | SOURCEANDSINK | Vakuum 2
Port_491780_1 | SOURCEANDSINK | Vakuum 2
Port_491812_0 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491822_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491812_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491832_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491814_2 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491815_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491814_3 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491822_1 | SOURCEANDSINK | Vzduch (4bar) 4
Port_491857_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491867_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491857_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491877_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491859_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491860_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491859_3 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491867_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491970_0 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491980_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491970_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491988_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491972_2 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491973_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491972_3 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_491980_1 | SOURCEANDSINK | O2 (4bar) 4 (1)
Port_492217_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493489_2 | SOURCEANDSINK | O2 (4bar) 2
Port_492217_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492255_2 | SOURCEANDSINK | O2 (4bar) 2
Port_492294_0 | SOURCEANDSINK | O2 (4bar) 2
Port_492378_2 | SOURCEANDSINK | O2 (4bar) 2
Port_492294_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492380_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492356_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493234_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492356_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492378_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492406_0 | SOURCEANDSINK | O2 (4bar) 2
Port_492427_2 | SOURCEANDSINK | O2 (4bar) 2
Port_492406_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492451_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492422_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492424_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492424_2 | SOURCEANDSINK | O2 (4bar) 2
Port_492427_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492443_0 | SOURCEANDSINK | O2 (4bar) 2
Port_492451_2 | SOURCEANDSINK | O2 (4bar) 2
Port_492443_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492460_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492454_0 | SOURCEANDSINK | O2 (4bar) 2
Port_492460_2 | SOURCEANDSINK | O2 (4bar) 2
Port_492454_1 | SOURCEANDSINK | O2 (4bar) 2
Port_518972_2 | SOURCEANDSINK | O2 (4bar) 2
Port_492463_0 | SOURCEANDSINK | O2 (4bar) 2
Port_518964_1 | SOURCEANDSINK | O2 (4bar) 2
Port_492463_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493351_2 | SOURCEANDSINK | O2 (4bar) 2
Port_492584_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492586_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492584_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492588_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492595_0 | SOURCEANDSINK | O2 (4bar) 9
Port_492597_2 | SOURCEANDSINK | O2 (4bar) 9
Port_492595_1 | SOURCEANDSINK | O2 (4bar) 9
Port_492599_1 | SOURCEANDSINK | O2 (4bar) 9
Port_492606_0 | SOURCEANDSINK | O2 (4bar) 1
Port_492608_2 | SOURCEANDSINK | O2 (4bar) 1
Port_492606_1 | SOURCEANDSINK | O2 (4bar) 1
Port_492610_1 | SOURCEANDSINK | O2 (4bar) 1
Port_492707_0 | SOURCEANDSINK | O2 (4bar) 1
Port_492709_2 | SOURCEANDSINK | O2 (4bar) 1
Port_492707_1 | SOURCEANDSINK | O2 (4bar) 1
Port_492711_1 | SOURCEANDSINK | O2 (4bar) 1
Port_492724_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492726_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492724_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492728_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492858_0 | SOURCEANDSINK | O2 (4bar) 1
Port_492860_2 | SOURCEANDSINK | O2 (4bar) 1
Port_492858_1 | SOURCEANDSINK | O2 (4bar) 1
Port_492862_1 | SOURCEANDSINK | O2 (4bar) 1
Port_492867_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492869_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492867_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492871_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492883_0 | SOURCEANDSINK | O2 (4bar) 1
Port_492885_2 | SOURCEANDSINK | O2 (4bar) 1
Port_492883_1 | SOURCEANDSINK | O2 (4bar) 1
Port_492887_1 | SOURCEANDSINK | O2 (4bar) 1
Port_492896_0 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492898_2 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492896_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492900_1 | SOURCEANDSINK | Vzduch (4bar) 3
Port_492909_0 | SOURCEANDSINK | Vakuum 1
Port_492911_2 | SOURCEANDSINK | Vakuum 1
Port_492909_1 | SOURCEANDSINK | Vakuum 1
Port_492913_1 | SOURCEANDSINK | Vakuum 1
Port_493172_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493182_2 | SOURCEANDSINK | O2 (4bar) 2
Port_493172_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493190_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493174_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493274_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493174_2 | SOURCEANDSINK | O2 (4bar) 2
Port_493175_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493174_3 | SOURCEANDSINK | O2 (4bar) 2
Port_493182_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493175_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493226_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493224_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493228_2 | SOURCEANDSINK | O2 (4bar) 2
Port_493224_1 | SOURCEANDSINK | O2 (4bar) 2
Port_519303_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493226_2 | SOURCEANDSINK | O2 (4bar) 2
Port_493228_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493271_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493281_2 | SOURCEANDSINK | O2 (4bar) 2
Port_493271_1 | SOURCEANDSINK | O2 (4bar) 2
Port_519243_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493273_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493476_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493273_2 | SOURCEANDSINK | O2 (4bar) 2
Port_493274_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493273_3 | SOURCEANDSINK | O2 (4bar) 2
Port_493281_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493287_1 | SOURCEANDSINK | O2 (4bar) 2
Port_519080_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493333_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493343_2 | SOURCEANDSINK | O2 (4bar) 2
Port_493333_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493351_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493335_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493418_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493335_2 | SOURCEANDSINK | O2 (4bar) 2
Port_493336_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493335_3 | SOURCEANDSINK | O2 (4bar) 2
Port_493343_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493336_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493475_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493415_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493425_2 | SOURCEANDSINK | O2 (4bar) 2
Port_493415_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493433_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493417_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493533_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493417_2 | SOURCEANDSINK | O2 (4bar) 2
Port_493418_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493417_3 | SOURCEANDSINK | O2 (4bar) 2
Port_493425_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493473_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493483_2 | SOURCEANDSINK | O2 (4bar) 2
Port_493473_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493491_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493475_2 | SOURCEANDSINK | O2 (4bar) 2
Port_493476_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493475_3 | SOURCEANDSINK | O2 (4bar) 2
Port_493483_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493530_0 | SOURCEANDSINK | O2 (4bar) 2
Port_493540_2 | SOURCEANDSINK | O2 (4bar) 2
Port_493530_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493548_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493532_2 | SOURCEANDSINK | O2 (4bar) 2
Port_493533_1 | SOURCEANDSINK | O2 (4bar) 2
Port_493532_3 | SOURCEANDSINK | O2 (4bar) 2
Port_493540_1 | SOURCEANDSINK | O2 (4bar) 2
Port_518912_0 | SOURCEANDSINK | O2 (4bar) 2
Port_518972_1 | SOURCEANDSINK | O2 (4bar) 2
Port_518912_1 | SOURCEANDSINK | O2 (4bar) 2
Port_518974_2 | SOURCEANDSINK | O2 (4bar) 2
Port_518962_0 | SOURCEANDSINK | O2 (4bar) 2
Port_518964_2 | SOURCEANDSINK | O2 (4bar) 2
Port_518962_1 | SOURCEANDSINK | O2 (4bar) 2
Port_518974_1 | SOURCEANDSINK | O2 (4bar) 2
Port_519080_1 | SOURCEANDSINK | O2 (4bar) 2
Port_519235_1 | SOURCEANDSINK | O2 (4bar) 2
Port_519150_0 | SOURCEANDSINK | O2 (4bar) 2
Port_519303_2 | SOURCEANDSINK | O2 (4bar) 2
Port_519150_1 | SOURCEANDSINK | O2 (4bar) 2
Port_519307_2 | SOURCEANDSINK | O2 (4bar) 2
Port_519233_0 | SOURCEANDSINK | O2 (4bar) 2
Port_519235_2 | SOURCEANDSINK | O2 (4bar) 2
Port_519233_1 | SOURCEANDSINK | O2 (4bar) 2
Port_519247_1 | SOURCEANDSINK | O2 (4bar) 2
Port_519293_0 | SOURCEANDSINK | O2 (4bar) 2
Port_519295_2 | SOURCEANDSINK | O2 (4bar) 2
Port_519293_1 | SOURCEANDSINK | O2 (4bar) 2
Port_519307_1 | SOURCEANDSINK | O2 (4bar) 2
Port_521592_0 | SOURCEANDSINK | Vakuum 1
Port_521674_1 | SOURCEANDSINK | Vakuum 1
Port_521592_1 | SOURCEANDSINK | Vakuum 1
Port_521676_2 | SOURCEANDSINK | Vakuum 1
Port_521664_0 | SOURCEANDSINK | Vakuum 1
Port_521666_2 | SOURCEANDSINK | Vakuum 1
Port_521664_1 | SOURCEANDSINK | Vakuum 1
Port_521676_1 | SOURCEANDSINK | Vakuum 1

# IfcFlowController: Plynový kulový ventil, 15–50 mm, se závitem:DN 10 (2)
In: Půdorys 1.PP
Type - Material: <Unnamed>
Type - NEMSOK - Výchozí výška: 0 mm; Délka: 26 mm; Délka páky: 80 mm; Jmenovitý poloměr: 6 mm; Jmenovitý průměr: 12 mm; PolT1: 15.0111 mm; PolT2: 17.5111 mm; PolZ1: 6.52174 mm; PolZ2: 4.34783 mm; Šířka: 75 mm; SW: 26 mm; SW2: 30.0222 mm; Výška: 30.0222 mm; Výška páky: 1 mm; Wdt1: 19.5652 mm; Wdt2: 9.78261 mm; Wdt3: 26.087 mm; Tlakový stupeň: PN; Název typu: DN 10; Označení typu: VE; Kategorie: Příslušenství trubek; Název rodiny: Plynový kulový ventil, 15–50 mm, se závitem
Pset_DistributionFlowElementCommon - Reference: DN 10; sets with these values: 2
NEMSOK - Tloušťka AllplanAttributes: 0 mm; Celková velikost: 12 mm-12 mm; CS_SCHEDULETYPEID: 457212; Číslo místnosti: Stoupačka; Jmenovitá velikost vstupu: 10 mm; Jmenovitá velikost výstupu: 10 mm; Podlaží: Podlaží 1.NP; Výška od podlaží: 500 mm; Klasifikace systému: Ostatní; Jmenovitý tlak: 4 bar; Tlaková ztráta: 0 Pa; Použít měřítko poznámky: no; Maximální velikost: 12 mm; Průměr: 12 mm; Objem: 0.0000565369 m3; Velikost: 12 mm-12 mm; Komentáře: Cu; Rodina: Plynový kulový ventil, 15–50 mm, se závitem; Id typu: 457212; Rodina a typ: Plynový kulový ventil, 15–50 mm, se závitem: DN 10; Typ: DN 10
Name (Plynový kulový ventil, 15–50 mm, se závitem:DN 10:...) | CS_SCHEDULEID = ID | Kód prvku | Fáze vytvoření | Teplonosná látka | Označení | Group
476865 | 476865 | VE.02.476865 | Existující | Vzduch | 9 | Vzduch (4bar) 3
480711 | 480711 | VE.02.480711 | Nová konstrukce | O2 | 10 | O2 (4bar) 1

# IfcFlowController: Plynový kulový ventil, 15–50 mm, se závitem:DN 15, Plynový kulový ventil, 15–50 mm, se závitem:DN 15:481572
In: Půdorys 1.PP
Type - Material: <Unnamed>
Type - NEMSOK - Výchozí výška: 0 mm; Délka: 26 mm; Délka páky: 80 mm; Jmenovitý poloměr: 9 mm; Jmenovitý průměr: 18 mm; PolT1: 15.0111 mm; PolT2: 17.5111 mm; PolZ1: 6.52174 mm; PolZ2: 4.34783 mm; Šířka: 75 mm; SW: 26 mm; SW2: 30.0222 mm; Výška: 30.0222 mm; Výška páky: 1.5 mm; Wdt1: 19.5652 mm; Wdt2: 9.78261 mm; Wdt3: 26.087 mm; Tlakový stupeň: PN; Název typu: DN 15; Označení typu: VE; Kategorie: Příslušenství trubek; Název rodiny: Plynový kulový ventil, 15–50 mm, se závitem
Pset_DistributionFlowElementCommon - Reference: DN 15; sets with these values: 2
NEMSOK - Tloušťka AllplanAttributes: 0 mm; Celková velikost: 18 mm-18 mm; CS_SCHEDULEID: 481572; CS_SCHEDULETYPEID: 451021; ID: 481572; Číslo místnosti: Stoupačka; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; Kód prvku: VE.02.481572; Podlaží: Podlaží 1.NP; Výška od podlaží: 1500 mm; Fáze vytvoření: Nová konstrukce; Teplonosná látka: O2; Klasifikace systému: Ostatní; Jmenovitý tlak: O2 (4bar) 9,O2 (4bar) 1; Tlaková ztráta: 0 Pa; Použít měřítko poznámky: no; Maximální velikost: 18 mm; Průměr: 18 mm; Objem: 0.0000569378 m3; Velikost: 18 mm-18 mm; Komentáře: Cu; Označení: 12; Rodina: Plynový kulový ventil, 15–50 mm, se závitem; Id typu: 451021; Rodina a typ: Plynový kulový ventil, 15–50 mm, se závitem: DN 15; Typ: DN 15
Group: O2 (4bar) 1; O2 (4bar) 9

# IfcFlowController: Plynový kulový ventil, 15–50 mm, se závitem:DN 20 (3)
In: Půdorys 1.NP
Type - Material: <Unnamed>
Type - NEMSOK - Výchozí výška: 0 mm; Délka: 32 mm; Délka páky: 80 mm; Jmenovitý poloměr: 11 mm; Jmenovitý průměr: 22 mm; PolT1: 18.4752 mm; PolT2: 20.9752 mm; PolZ1: 6.95652 mm; PolZ2: 4.63768 mm; Šířka: 80 mm; SW: 32 mm; SW2: 36.9504 mm; Výška: 36.9504 mm; Výška páky: 1.83333 mm; Wdt1: 20.8696 mm; Wdt2: 10.4348 mm; Wdt3: 27.8261 mm; Tlakový stupeň: PN; Název typu: DN 20; Označení typu: VE; Kategorie: Příslušenství trubek; Název rodiny: Plynový kulový ventil, 15–50 mm, se závitem
Pset_DistributionFlowElementCommon - Reference: DN 20; sets with these values: 2
NEMSOK - Tloušťka AllplanAttributes: 0 mm; Celková velikost: 22 mm-22 mm; CS_SCHEDULETYPEID: 451011; Číslo místnosti: Stoupačka; Jmenovitá velikost vstupu: 20 mm; Jmenovitá velikost výstupu: 20 mm; Podlaží: Podlaží 1.NP; Výška od podlaží: 1400 mm; Fáze vytvoření: Nová konstrukce; Klasifikace systému: Ostatní; Jmenovitý tlak: 4 bar; Tlaková ztráta: 0 Pa; Použít měřítko poznámky: no; Maximální velikost: 22 mm; Průměr: 22 mm; Objem: 0.0000892103 m3; Velikost: 22 mm-22 mm; Komentáře: Cu; Id typu: 451011; Rodina: Plynový kulový ventil, 15–50 mm, se závitem; Rodina a typ: Plynový kulový ventil, 15–50 mm, se závitem: DN 20; Typ: DN 20
Name (Plynový kulový ventil, 15–50 mm, se závitem:DN 20:...) | CS_SCHEDULEID = ID | Kód prvku | Teplonosná látka | Označení | Group
456691 | 456691 | VE.03.456691 | Vakuum | 3 | Vakuum 1
456743 | 456743 | VE.03.456743 | Vzduch | 4 | Vzduch (4bar) 3
456789 | 456789 | VE.03.456789 | O2 | 5 | O2 (4bar) 1

# IfcFlowController: Plynový kulový ventil, 15–50 mm, se závitem:DN 25 (2)
In: Půdorys 1.PP
Type - Material: <Unnamed>
Type - NEMSOK - Výchozí výška: 0 mm; Délka: 41 mm; Délka páky: 90 mm; Jmenovitý poloměr: 14 mm; Jmenovitý průměr: 28 mm; PolT1: 23.6714 mm; PolT2: 26.1714 mm; PolZ1: 7.82609 mm; PolZ2: 5.21739 mm; Šířka: 90 mm; SW: 41 mm; SW2: 47.3427 mm; Výška: 47.3427 mm; Výška páky: 2.33333 mm; Wdt1: 23.4783 mm; Wdt2: 11.7391 mm; Wdt3: 31.3043 mm; Tlakový stupeň: PN; Název typu: DN 25; Označení typu: VE; Kategorie: Příslušenství trubek; Název rodiny: Plynový kulový ventil, 15–50 mm, se závitem
Pset_DistributionFlowElementCommon - Reference: DN 25; sets with these values: 2
NEMSOK - Tloušťka AllplanAttributes: 0 mm; Celková velikost: 28 mm-28 mm; CS_SCHEDULETYPEID: 451013; Číslo místnosti: Stoupačka; Jmenovitá velikost vstupu: 25 mm; Jmenovitá velikost výstupu: 25 mm; Podlaží: Podlaží 1.NP; Výška od podlaží: 1250 mm; Fáze vytvoření: Nová konstrukce; Klasifikace systému: Ostatní; Jmenovitý tlak: 4 bar; Tlaková ztráta: 0 Pa; Použít měřítko poznámky: no; Maximální velikost: 28 mm; Průměr: 28 mm; Objem: 0.000160378 m3; Velikost: 28 mm-28 mm; Komentáře: Cu; Rodina: Plynový kulový ventil, 15–50 mm, se závitem; Id typu: 451013; Rodina a typ: Plynový kulový ventil, 15–50 mm, se závitem: DN 25; Typ: DN 25
Name (Plynový kulový ventil, 15–50 mm, se závitem:DN 25:...) | CS_SCHEDULEID = ID | Kód prvku | Teplonosná látka | Označení | Group
480936 | 480936 | VE.02.480936 | O2 | 11 | O2 (4bar) 1
485395 | 485395 | VE.02.485395 | Vzduch | 13 | Vzduch (4bar) 3

# IfcFlowFitting: Koleno ohyb - pájení natvrdo - CU:Standard (246)
Type - Material: <Unnamed>
Type - NEMSOK - Výchozí výška: 0 mm; Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Long Radius Flanged 45, 90 and 180 Elbow; Tlakový stupeň: PN; Název typu: Standard; Označení typu: TT; Kategorie: Tvarovky; Lookup Table Name: Bend Slow - Brazed - CU; Název rodiny: Koleno ohyb - pájení natvrdo - CU
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
NEMSOK - Tloušťka AllplanAttributes: 0 mm; Fáze vytvoření: Nová konstrukce; Klasifikace systému: Ostatní; Jmenovitý tlak: 4 bar; Použít měřítko poznámky: no; Angle: 90 deg; Id typu: 257978; Rodina: Koleno ohyb - pájení natvrdo - CU; Rodina a typ: Koleno ohyb - pájení natvrdo - CU: Standard; Typ: Standard
Name (Koleno ohyb - pájení natvrdo - CU:Standard:...) | In | NominalDiameter = Fitting Outside Diameter (mm) = Maximální velikost (mm) = Průměr (mm) | Celková velikost = Velikost | CS_SCHEDULEID = ID | CS_SCHEDULETYPEID | Kód prvku | Podlaží | Výška od podlaží (mm) | Teplonosná látka | Centre to End (mm) = Length 1 (mm) = Length 2 (mm) | Nominal Radius (mm) = Fitting Outside Radius (mm) | Objem (m3) | Socket Outside Diameter (mm) | Socket Width (mm) | Tick Size (mm) | Wall Thickness (mm) | Komentáře | Centre Radius (mm) = Length 3 (mm) = Length 4 (mm) | Socket Outside Radius (mm) | Group
438992 | Půdorys 1.NP | 22 | 22 mm-22 mm | 438992 | 257978 | TT.03.438992 | Podlaží 1.NP | 2700 | Vakuum | 41.42 | 11 | 0.0000269698 | 23.44 | 8.42 | 8.8 | 0.72 | Cu | 33 | 11.72 | Vakuum 1
439055 | Půdorys 1.NP | 22 | 22 mm-22 mm | 439055 | 257978 | TT.03.439055 | Podlaží 1.NP | 2700 | Vzduch | 41.42 | 11 | 0.0000269698 | 23.44 | 8.42 | 8.8 | 0.72 | Cu | 33 | 11.72 | Vzduch (4bar) 3
439089 | Půdorys 1.NP | 22 | 22 mm-22 mm | 439089 | 257978 | TT.03.439089 | Podlaží 1.NP | 2700 | O2 | 41.42 | 11 | 0.0000269698 | 23.44 | 8.42 | 8.8 | 0.72 | Cu | 33 | 11.72 | O2 (4bar) 1
442249 | Půdorys 1.NP | 22 | 22 mm-22 mm | 442249 | 257978 | TT.03.442249 | Podlaží 1.NP | 1250 | O2 | 41.42 | 11 | 0.0000269698 | 23.44 | 8.42 | 8.8 | 0.72 | Cu | 33 | 11.72 | O2 (4bar) 1
442353 | Půdorys 1.NP | 22 | 22 mm-22 mm | 442353 | 257978 | TT.03.442353 | Podlaží 1.NP | 1250 | Vakuum | 41.42 | 11 | 0.0000269698 | 23.44 | 8.42 | 8.8 | 0.72 | Cu | 33 | 11.72 | Vakuum 1
442440 | Půdorys 1.NP | 22 | 22 mm-22 mm | 442440 | 257978 | TT.03.442440 | Podlaží 1.NP | 1250 | Vzduch | 41.42 | 11 | 0.0000269698 | 23.44 | 8.42 | 8.8 | 0.72 | Cu | 33 | 11.72 | Vzduch (4bar) 3
442829 | Půdorys 1.PP | 18 | 18 mm-18 mm | 442829 | 257978 | TT.02.442829 | Podlaží 1.NP | 2410 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 2
443845 | Půdorys 1.PP | 12 | 12 mm-12 mm | 443845 | 257978 | TT.02.443845 | Podlaží 1.NP | 2680 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 2
446619 | Půdorys 1.NP | 18 | 18 mm-18 mm | 446619 | 257978 | TT.03.446619 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 3
446917 | Půdorys 1.NP | 18 | 18 mm-18 mm | 446917 | 257978 | TT.03.446917 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vzduch (4bar) 2
446925 | Půdorys 1.NP | 18 | 18 mm-18 mm | 446925 | 257978 | TT.03.446925 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vakuum 4
446958 | Půdorys 1.NP | 18 | 18 mm-18 mm | 446958 | 257978 | TT.03.446958 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 4 (1)
446960 | Půdorys 1.NP | 18 | 18 mm-18 mm | 446960 | 257978 | TT.03.446960 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vzduch (4bar) 4
446964 | Půdorys 1.NP | 18 | 18 mm-18 mm | 446964 | 257978 | TT.03.446964 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vakuum 2
449554 | Půdorys 1.NP | 8 | 8 mm-8 mm | 449554 | 257978 | TT.03.449554 | Podlaží 1.NP | 2865 | O2 | 16.78 | 4 | 0.00000168838 | 9.16 | 6.88 | 3.2 | 0.58 | Cu | 9.9 | 4.58 | O2 (4bar) 4 (1)
449641 | Půdorys 1.NP | 8 | 8 mm-8 mm | 449641 | 257978 | TT.03.449641 | Podlaží 1.NP | 2865 | O2 | 16.78 | 4 | 0.00000168838 | 9.16 | 6.88 | 3.2 | 0.58 | Cu | 9.9 | 4.58 | O2 (4bar) 4 (1)
449658 | Půdorys 1.NP | 12 | 12 mm-12 mm | 449658 | 257978 | TT.03.449658 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 4 (1)
457029 | Půdorys 1.NP | 12 | 12 mm-12 mm | 457029 | 257978 | TT.03.457029 | Podlaží 1.NP | 1550 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 1
457103 | Půdorys 1.NP | 12 | 12 mm-12 mm | 457103 | 257978 | TT.03.457103 | Podlaží 1.NP | 1550 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 3
457150 | Půdorys 1.NP | 12 | 12 mm-12 mm | 457150 | 257978 | TT.03.457150 | Podlaží 1.NP | 1550 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 1
457812 | Půdorys 1.NP | 18 | 18 mm-18 mm | 457812 | 257978 | TT.03.457812 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vakuum 2
457820 | Půdorys 1.NP | 18 | 18 mm-18 mm | 457820 | 257978 | TT.03.457820 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vzduch (4bar) 4
457828 | Půdorys 1.NP | 18 | 18 mm-18 mm | 457828 | 257978 | TT.03.457828 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 4 (1)
474538 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474538 | 257978 | TT.03.474538 | Podlaží 1.NP | 1470.5 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 4 (1)
474570 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474570 | 257978 | TT.03.474570 | Podlaží 1.NP | 2950 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 4 (1)
474572 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474572 | 257978 | TT.03.474572 | Podlaží 1.NP | 2950 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 4 (1)
474608 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474608 | 257978 | TT.03.474608 | Podlaží 1.NP | 1470.5 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 2
474612 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474612 | 257978 | TT.03.474612 | Podlaží 1.NP | 2950 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 2
474616 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474616 | 257978 | TT.03.474616 | Podlaží 1.NP | 2950 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 2
474667 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474667 | 257978 | TT.03.474667 | Podlaží 1.NP | 1470.5 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 4
474682 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474682 | 257978 | TT.03.474682 | Podlaží 1.NP | 2950 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 4
474684 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474684 | 257978 | TT.03.474684 | Podlaží 1.NP | 2950 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 4
474720 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474720 | 257978 | TT.03.474720 | Podlaží 1.NP | 1470.5 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 4
474775 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474775 | 257978 | TT.03.474775 | Podlaží 1.NP | 1470.5 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 4
474825 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474825 | 257978 | TT.03.474825 | Podlaží 1.NP | 1470.5 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 4
474829 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474829 | 257978 | TT.03.474829 | Podlaží 1.NP | 3050 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 4
474901 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474901 | 257978 | TT.03.474901 | Podlaží 1.NP | 1470.5 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 2
474944 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474944 | 257978 | TT.03.474944 | Podlaží 1.NP | 1470.5 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 2
474987 | Půdorys 1.NP | 12 | 12 mm-12 mm | 474987 | 257978 | TT.03.474987 | Podlaží 1.NP | 1470.5 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 2
475129 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475129 | 257978 | TT.03.475129 | Podlaží 1.NP | 1470.5 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 2
475173 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475173 | 257978 | TT.03.475173 | Podlaží 1.NP | 1470.5 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 4
475192 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475192 | 257978 | TT.03.475192 | Podlaží 1.NP | 2950 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 4
475198 | Půdorys 1.NP | 18 | 18 mm-18 mm | 475198 | 257978 | TT.03.475198 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vzduch (4bar) 2
475202 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475202 | 257978 | TT.03.475202 | Podlaží 1.NP | 2950 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 2
475224 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475224 | 257978 | TT.03.475224 | Podlaží 1.NP | 1470.5 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 3
475243 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475243 | 257978 | TT.03.475243 | Podlaží 1.NP | 2950 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 3
475411 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475411 | 257978 | TT.03.475411 | Podlaží 1.NP | 1470.5 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 4
475456 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475456 | 257978 | TT.03.475456 | Podlaží 1.NP | 1470.5 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 4
475499 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475499 | 257978 | TT.03.475499 | Podlaží 1.NP | 1470.5 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 4
475544 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475544 | 257978 | TT.03.475544 | Podlaží 1.NP | 1470.5 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 4 (1)
475548 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475548 | 257978 | TT.03.475548 | Podlaží 1.NP | 3050 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 4 (1)
475596 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475596 | 257978 | TT.03.475596 | Podlaží 1.NP | 1470.5 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 2
475639 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475639 | 257978 | TT.03.475639 | Podlaží 1.NP | 1470.5 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 2
475687 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475687 | 257978 | TT.03.475687 | Podlaží 1.NP | 1470.5 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 4 (1)
475730 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475730 | 257978 | TT.03.475730 | Podlaží 1.NP | 1470.5 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 4 (1)
475773 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475773 | 257978 | TT.03.475773 | Podlaží 1.NP | 1470.5 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 2
475777 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475777 | 257978 | TT.03.475777 | Podlaží 1.NP | 3050 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 2
475810 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475810 | 257978 | TT.03.475810 | Podlaží 1.NP | 1470.5 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 3
475857 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475857 | 257978 | TT.03.475857 | Podlaží 1.NP | 1470.5 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 3
475900 | Půdorys 1.NP | 12 | 12 mm-12 mm | 475900 | 257978 | TT.03.475900 | Podlaží 1.NP | 1470.5 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 3
476469 | Půdorys 1.PP | 18 | 18 mm-18 mm | 476469 | 257978 | TT.02.476469 | Podlaží 1.NP | 2410 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 9
476584 | Půdorys 1.PP | 28 | 28 mm-28 mm | 476584 | 257978 | TT.02.476584 | Podlaží 1.NP | 2560 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | O2 (4bar) 1
476595 | Půdorys 1.PP | 28 | 28 mm-28 mm | 476595 | 257978 | TT.02.476595 | Podlaží 1.NP | 2560 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | O2 (4bar) 1
476680 | Půdorys 1.PP | 28 | 28 mm-28 mm | 476680 | 257978 | TT.02.476680 | Podlaží 1.NP | 2560 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | Vzduch (4bar) 3
476715 | Půdorys 1.PP | 28 | 28 mm-28 mm | 476715 | 257978 | TT.02.476715 | Podlaží 1.NP | 2560 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | Vzduch (4bar) 3
476810 | Půdorys 1.PP | 28 | 28 mm-28 mm | 476810 | 257978 | TT.02.476810 | Podlaží 1.NP | 2560 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | Vzduch (4bar) 3
476921 | Půdorys 1.PP | 28 | 28 mm-28 mm | 476921 | 257978 | TT.02.476921 | Podlaží 1.NP | 2950 | Vakuum | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | Vakuum 1
479083 | Půdorys 1.PP | 12 | 12 mm-12 mm | 479083 | 257978 | TT.02.479083 | Podlaží 1.NP | 2750 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 2
479186 | Půdorys 1.PP | 12 | 12 mm-12 mm | 479186 | 257978 | TT.02.479186 | Podlaží 1.NP | 2750 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 2
479917 | Půdorys 1.NP | 12 | 12 mm-12 mm | 479917 | 257978 | TT.03.479917 | Podlaží 1.NP | 1470.5 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 3
479963 | Půdorys 1.NP | 12 | 12 mm-12 mm | 479963 | 257978 | TT.03.479963 | Podlaží 1.NP | 1470.5 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 2
480004 | Půdorys 1.NP | 12 | 12 mm-12 mm | 480004 | 257978 | TT.03.480004 | Podlaží 1.NP | 1470.5 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 4
480223 | Půdorys 1.NP | 22 | 22 mm-22 mm | 480223 | 257978 | TT.03.480223 | Podlaží 1.NP | 2700 | Vakuum | 41.42 | 11 | 0.0000269698 | 23.44 | 8.42 | 8.8 | 0.72 | Cu | 33 | 11.72 | Vakuum 1
480225 | Půdorys 1.NP | 22 | 22 mm-22 mm | 480225 | 257978 | TT.03.480225 | Podlaží 1.NP | 2700 | Vzduch | 41.42 | 11 | 0.0000269698 | 23.44 | 8.42 | 8.8 | 0.72 | Cu | 33 | 11.72 | Vzduch (4bar) 3
480227 | Půdorys 1.NP | 22 | 22 mm-22 mm | 480227 | 257978 | TT.03.480227 | Podlaží 1.NP | 2700 | Vzduch | 41.42 | 11 | 0.0000269698 | 23.44 | 8.42 | 8.8 | 0.72 | Cu | 33 | 11.72 | Vzduch (4bar) 3
480231 | Půdorys 1.NP | 22 | 22 mm-22 mm | 480231 | 257978 | TT.03.480231 | Podlaží 1.NP | 2700 | O2 | 41.42 | 11 | 0.0000269698 | 23.44 | 8.42 | 8.8 | 0.72 | Cu | 33 | 11.72 | O2 (4bar) 1
480854 | Půdorys 1.PP | 28 | 28 mm-28 mm | 480854 | 257978 | TT.02.480854 | Podlaží 1.NP | 2560 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | O2 (4bar) 1
480860 | Půdorys 1.NP | 28 | 28 mm-28 mm | 480860 | 257978 | TT.02.480860 | Podlaží 1.NP | -2300 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | O2 (4bar) 1
480862 | Půdorys 1.NP | 28 | 28 mm-28 mm | 480862 | 257978 | TT.02.480862 | Podlaží 1.NP | -740 | O2 | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | O2 (4bar) 1
481331 | Půdorys 1.PP | 12 | 12 mm-12 mm | 481331 | 257978 | TT.02.481331 | Podlaží 1.NP | 1700 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 1
481428 | Půdorys 1.PP | 12 | 12 mm-12 mm | 481428 | 257978 | TT.02.481428 | Podlaží 1.NP | 1700 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 9
481538 | Půdorys 1.NP | 18 | 18 mm-18 mm | 481538 | 257978 | TT.02.481538 | Podlaží 1.NP | -1906 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 1
481702 | Půdorys 1.PP | 18 | 18 mm-18 mm | 481702 | 257978 | TT.02.481702 | Podlaží 1.NP | 2560 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 9
481962 | Půdorys 1.PP | 18 | 18 mm-18 mm | 481962 | 257978 | TT.02.481962 | Podlaží 1.NP | 2560 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 9
481964 | Půdorys 1.PP | 18 | 18 mm-18 mm | 481964 | 257978 | TT.02.481964 | Podlaží 1.NP | 2560 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 9
482186 | Půdorys 1.PP | 12 | 12 mm-12 mm | 482186 | 257978 | TT.02.482186 | Podlaží 1.NP | 2750 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 2
485280 | Půdorys 1.PP | 18 | 18 mm-18 mm | 485280 | 257978 | TT.02.485280 | Podlaží 1.NP | 2560 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 9
485409 | Půdorys 1.PP | 12 | 12 mm-12 mm | 485409 | 257978 | TT.02.485409 | Podlaží 1.NP | 1700 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 3
485446 | Půdorys 1.NP | 28 | 28 mm-28 mm | 485446 | 257978 | TT.02.485446 | Podlaží 1.NP | -2300 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | Vzduch (4bar) 3
485513 | Půdorys 1.PP | 28 | 28 mm-28 mm | 485513 | 257978 | TT.02.485513 | Podlaží 1.NP | 2560 | Vzduch | 51.98 | 14 | 0.0000539529 | 29.56 | 9.08 | 11.2 | 0.78 | Cu | 42.9 | 14.78 | Vzduch (4bar) 3
486862 | Půdorys 1.NP | 18 | 18 mm-18 mm | 486862 | 257978 | TT.03.486862 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 3
486866 | Půdorys 1.NP | 18 | 18 mm-18 mm | 486866 | 257978 | TT.03.486866 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 3
486889 | Půdorys 1.NP | 18 | 18 mm-18 mm | 486889 | 257978 | TT.03.486889 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 4 (1)
486893 | Půdorys 1.NP | 18 | 18 mm-18 mm | 486893 | 257978 | TT.03.486893 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 4 (1)
486917 | Půdorys 1.NP | 18 | 18 mm-18 mm | 486917 | 257978 | TT.03.486917 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vzduch (4bar) 2
486921 | Půdorys 1.NP | 18 | 18 mm-18 mm | 486921 | 257978 | TT.03.486921 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vzduch (4bar) 2
486974 | Půdorys 1.NP | 18 | 18 mm-18 mm | 486974 | 257978 | TT.03.486974 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vzduch (4bar) 4
486976 | Půdorys 1.NP | 18 | 18 mm-18 mm | 486976 | 257978 | TT.03.486976 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vzduch (4bar) 4
487032 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487032 | 257978 | TT.03.487032 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vakuum 2
487036 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487036 | 257978 | TT.03.487036 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vakuum 2
487074 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487074 | 257978 | TT.03.487074 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vakuum 4
487076 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487076 | 257978 | TT.03.487076 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vakuum 4
487271 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487271 | 257978 | TT.03.487271 | Podlaží 1.NP | 2700 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vakuum 1
487284 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487284 | 257978 | TT.03.487284 | Podlaží 1.NP | 2700 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vakuum 1
487352 | Půdorys 1.NP | 22 | 22 mm-22 mm | 487352 | 257978 | TT.03.487352 | Podlaží 1.NP | 2700 | Vakuum | 41.42 | 11 | 0.0000269698 | 23.44 | 8.42 | 8.8 | 0.72 | Cu | 33 | 11.72 | Vakuum 1
487391 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487391 | 257978 | TT.03.487391 | Podlaží 1.NP | 2900 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vakuum 1 | NEMSOK - Tlaková ztráta: 0 Pa
487395 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487395 | 257978 | TT.03.487395 | Podlaží 1.NP | 2900 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vakuum 1
487476 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487476 | 257978 | TT.03.487476 | Podlaží 1.NP | 2900 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vzduch (4bar) 3
487480 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487480 | 257978 | TT.03.487480 | Podlaží 1.NP | 2900 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vzduch (4bar) 3
487496 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487496 | 257978 | TT.03.487496 | Podlaží 1.NP | 2700 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vzduch (4bar) 3
487509 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487509 | 257978 | TT.03.487509 | Podlaží 1.NP | 2700 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vzduch (4bar) 3
487529 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487529 | 257978 | TT.03.487529 | Podlaží 1.NP | 2700 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 1
487567 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487567 | 257978 | TT.03.487567 | Podlaží 1.NP | 2700 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 1
487571 | Půdorys 1.NP | 22 | 22 mm-22 mm | 487571 | 257978 | TT.03.487571 | Podlaží 1.NP | 2700 | O2 | 41.42 | 11 | 0.0000269698 | 23.44 | 8.42 | 8.8 | 0.72 | Cu | 33 | 11.72 | O2 (4bar) 1
487660 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487660 | 257978 | TT.03.487660 | Podlaží 1.NP | 2900 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 1
487664 | Půdorys 1.NP | 18 | 18 mm-18 mm | 487664 | 257978 | TT.03.487664 | Podlaží 1.NP | 2900 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 1
488572 | Půdorys 1.NP | 18 | 18 mm-18 mm | 488572 | 257978 | TT.03.488572 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vakuum 4
488579 | Půdorys 1.NP | 18 | 18 mm-18 mm | 488579 | 257978 | TT.03.488579 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 3
489835 | Půdorys 1.NP | 18 | 18 mm-18 mm | 489835 | 257978 | TT.03.489835 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vakuum 2
489839 | Půdorys 1.NP | 18 | 18 mm-18 mm | 489839 | 257978 | TT.03.489839 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vzduch (4bar) 4
489847 | Půdorys 1.NP | 18 | 18 mm-18 mm | 489847 | 257978 | TT.03.489847 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vakuum 4
489849 | Půdorys 1.NP | 18 | 18 mm-18 mm | 489849 | 257978 | TT.03.489849 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vakuum 4
489851 | Půdorys 1.NP | 18 | 18 mm-18 mm | 489851 | 257978 | TT.03.489851 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vzduch (4bar) 2
489853 | Půdorys 1.NP | 18 | 18 mm-18 mm | 489853 | 257978 | TT.03.489853 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vzduch (4bar) 2
489855 | Půdorys 1.NP | 18 | 18 mm-18 mm | 489855 | 257978 | TT.03.489855 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | O2 (4bar) 3
489857 | Půdorys 1.NP | 18 | 18 mm-18 mm | 489857 | 257978 | TT.03.489857 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | O2 (4bar) 3
489955 | Půdorys 1.NP | 12 | 12 mm-12 mm | 489955 | 257978 | TT.03.489955 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 4 (1)
489960 | Půdorys 1.NP | 12 | 12 mm-12 mm | 489960 | 257978 | TT.03.489960 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 4 (1)
489962 | Půdorys 1.NP | 12 | 12 mm-12 mm | 489962 | 257978 | TT.03.489962 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 4 (1)
490549 | Půdorys 1.NP | 18 | 18 mm-18 mm | 490549 | 257978 | TT.03.490549 | Podlaží 1.NP | 3050 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vakuum 2
490581 | Půdorys 1.NP | 18 | 18 mm-18 mm | 490581 | 257978 | TT.03.490581 | Podlaží 1.NP | 3050 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vzduch (4bar) 4
490610 | Půdorys 1.NP | 18 | 18 mm-18 mm | 490610 | 257978 | TT.03.490610 | Podlaží 1.NP | 3050 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | O2 (4bar) 4 (1)
490647 | Půdorys 1.NP | 18 | 18 mm-18 mm | 490647 | 257978 | TT.03.490647 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vakuum 2
490649 | Půdorys 1.NP | 18 | 18 mm-18 mm | 490649 | 257978 | TT.03.490649 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vakuum 2
490680 | Půdorys 1.NP | 18 | 18 mm-18 mm | 490680 | 257978 | TT.03.490680 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vzduch (4bar) 4
490682 | Půdorys 1.NP | 18 | 18 mm-18 mm | 490682 | 257978 | TT.03.490682 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vzduch (4bar) 4
490710 | Půdorys 1.NP | 18 | 18 mm-18 mm | 490710 | 257978 | TT.03.490710 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | O2 (4bar) 4 (1)
490712 | Půdorys 1.NP | 18 | 18 mm-18 mm | 490712 | 257978 | TT.03.490712 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | O2 (4bar) 4 (1)
490720 | Půdorys 1.NP | 18 | 18 mm-18 mm | 490720 | 257978 | TT.03.490720 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | O2 (4bar) 3
490722 | Půdorys 1.NP | 18 | 18 mm-18 mm | 490722 | 257978 | TT.03.490722 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vzduch (4bar) 2
490724 | Půdorys 1.NP | 18 | 18 mm-18 mm | 490724 | 257978 | TT.03.490724 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 |  | 26.4 | 9.68 | Vakuum 4
490865 | Půdorys 1.NP | 12 | 12 mm-12 mm | 490865 | 257978 | TT.03.490865 | Podlaží 1.NP | 3050 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 4 (1)
490869 | Půdorys 1.NP | 12 | 12 mm-12 mm | 490869 | 257978 | TT.03.490869 | Podlaží 1.NP | 3050 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | Vzduch (4bar) 4
490873 | Půdorys 1.NP | 12 | 12 mm-12 mm | 490873 | 257978 | TT.03.490873 | Podlaží 1.NP | 3050 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | Vakuum 2
490991 | Půdorys 1.NP | 12 | 12 mm-12 mm | 490991 | 257978 | TT.03.490991 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 3
490995 | Půdorys 1.NP | 12 | 12 mm-12 mm | 490995 | 257978 | TT.03.490995 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 3
491032 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491032 | 257978 | TT.03.491032 | Podlaží 1.NP | 2865 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 2
491036 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491036 | 257978 | TT.03.491036 | Podlaží 1.NP | 2865 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | Vzduch (4bar) 2
491073 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491073 | 257978 | TT.03.491073 | Podlaží 1.NP | 2865 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 4
491077 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491077 | 257978 | TT.03.491077 | Podlaží 1.NP | 2865 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | Vakuum 4
491138 | Půdorys 1.NP | 18 | 18 mm-18 mm | 491138 | 257978 | TT.03.491138 | Podlaží 1.NP | 2950 | O2 | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | O2 (4bar) 3
491140 | Půdorys 1.NP | 18 | 18 mm-18 mm | 491140 | 257978 | TT.03.491140 | Podlaží 1.NP | 2950 | Vzduch | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vzduch (4bar) 2
491142 | Půdorys 1.NP | 18 | 18 mm-18 mm | 491142 | 257978 | TT.03.491142 | Podlaží 1.NP | 2950 | Vakuum | 34.38 | 9 | 0.0000152499 | 19.36 | 7.98 | 7.2 | 0.68 | Cu | 26.4 | 9.68 | Vakuum 4
491180 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491180 | 257978 | TT.03.491180 | Podlaží 1.NP | 2865 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vakuum 4
491184 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491184 | 257978 | TT.03.491184 | Podlaží 1.NP | 2865 | Vakuum | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | Vakuum 4
491221 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491221 | 257978 | TT.03.491221 | Podlaží 1.NP | 2865 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | Vzduch (4bar) 2
491225 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491225 | 257978 | TT.03.491225 | Podlaží 1.NP | 2865 | Vzduch | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | Vzduch (4bar) 2
491262 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491262 | 257978 | TT.03.491262 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 3
491266 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491266 | 257978 | TT.03.491266 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 |  | 16.5 | 6.62 | O2 (4bar) 3
491304 | Půdorys 1.NP | 12 | 12 mm-12 mm | 491304 | 257978 | TT.03.491304 | Podlaží 1.NP | 2865 | O2 | 23.82 | 6 | 0.00000494662 | 13.24 | 7.32 | 4.8 | 0.62 | Cu | 16.5 | 6.62 | O2 (4bar) 3
