Properties of the parts of a building model (IFC2X3), part 4 of 5

# IfcFlowSegment: Typy trubek:Měď - EN 13348 - pájení natvrdo (350)
Name (Typy trubek:Měď - EN 13348 - pájení natvrdo:...) | In | Length (mm) = Délka (mm) | Celková velikost = Velikost | Výška dolní hrany AllplanAttributes dole (mm) = Výška dolní hrany dole (mm) | Výška dolní hrany AllplanAttributes nahoře (mm) = Výška dolní hrany nahoře (mm) | Výška horní hrany AllplanAttributes dole (mm) = Výška horní hrany dole (mm) | Výška horní hrany AllplanAttributes nahoře (mm) = Výška horní hrany nahoře (mm) | CS_SCHEDULEID = ID | CS_SCHEDULETYPEID | Relativní drsnost | Kód prvku | Podlaží | Koncová výška osy (mm) | Počáteční výška osy (mm) = Výška osy (mm) | Referenční podlaží | Sklon | Výška dna trubky dole (mm) | Výška dna trubky nahoře (mm) | Výška osy dole (mm) | Výška osy nahoře (mm) | Výška stropu trubky dole (mm) | Výška stropu trubky nahoře (mm) | Fáze vytvoření | Drsnost (mm) | Materiál | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) = Vnější průměr (mm) | Řez | Teplonosná látka | Úsek potrubí | Výkaz/typ | Tloustka (mm) | Vnitřní průměr (mm) | Komentáře | Group
449629 | Půdorys 1.NP | 624.629 | 12 mm | 2859 | 2859 | 2871 | 2871 | 449629 | 432495 | 0.000254 | TR.03.449629 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.023548 | 12 | 16 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
449639 | Půdorys 1.NP | 1371.52 | 8 mm | 1476.7 | 2848.22 | 1476.7 | 2848.22 | 449639 | 432495 | 0.000423333 | TR.03.449639 | Podlaží 1.NP | 2848.22 | 1476.7 | Podlaží 1.NP |  | 1476.7 | 2848.22 | 1476.7 | 2848.22 | 1476.7 | 2848.22 | Nová konstrukce | 0.00254 | Kov - Měď | 1476.7 | 0.0344701 | 8 | 17 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 6 | Cu | O2 (4bar) 4 (1)
449646 | Půdorys 1.NP | 3894.25 | 12 mm | 2859 | 2859 | 2871 | 2871 | 449646 | 432495 | 0.000254 | TR.03.449646 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.14681 | 12 | 16 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
449655 | Půdorys 1.NP | 5442.79 | 12 mm | 2859 | 2859 | 2871 | 2871 | 449655 | 432495 | 0.000254 | TR.03.449655 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.205188 | 12 | 68 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
456584 | Půdorys 1.PP | 1816.02 | 28 mm | 2701.98 | 4518 | 2701.98 | 4518 | 456584 | 432495 | 0.0001016 | TR.02.456584 | Podlaží 1.NP | 2701.98 | 4518 | Podlaží 1.PP |  | 2701.98 | 4518 | 2701.98 | 4518 | 2701.98 | 4518 | Nová konstrukce | 0.00254 | Kov - Měď | -598.02 | 0.159745 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
456693 | Půdorys 1.NP | 81.6 | 22 mm | 1440 | 1521.6 | 1440 | 1521.6 | 456693 | 432495 | 0.000127 | TR.03.456693 | Podlaží 1.NP | 1440 | 1521.6 | Podlaží 1.NP |  | 1440 | 1521.6 | 1440 | 1521.6 | 1440 | 1521.6 | Nová konstrukce | 0.00254 | Kov - Měď | 1440 | 0.00563979 | 22 | 1 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vakuum 1
456745 | Půdorys 1.NP | 81.6 | 22 mm | 1440 | 1521.6 | 1440 | 1521.6 | 456745 | 432495 | 0.000127 | TR.03.456745 | Podlaží 1.NP | 1440 | 1521.6 | Podlaží 1.NP |  | 1440 | 1521.6 | 1440 | 1521.6 | 1440 | 1521.6 | Nová konstrukce | 0.00254 | Kov - Měď | 1440 | 0.00563979 | 22 | 5 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vzduch (4bar) 3
456791 | Půdorys 1.NP | 81.6 | 22 mm | 1440 | 1521.6 | 1440 | 1521.6 | 456791 | 432495 | 0.000127 | TR.03.456791 | Podlaží 1.NP | 1440 | 1521.6 | Podlaží 1.NP |  | 1440 | 1521.6 | 1440 | 1521.6 | 1440 | 1521.6 | Nová konstrukce | 0.00254 | Kov - Měď | 1440 | 0.00563979 | 22 | 14 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | O2 (4bar) 1
456912 | Půdorys 1.NP | 26.18 | 12 mm | 1573.82 | 1600 | 1573.82 | 1600 | 456912 | 432495 | 0.000254 | TR.03.456912 | Podlaží 1.NP | 1573.82 | 1600 | Podlaží 1.NP |  | 1573.82 | 1600 | 1573.82 | 1600 | 1573.82 | 1600 | Nová konstrukce | 0.00254 | Kov - Měď | 1573.82 | 0.000986963 | 12 | 26 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 1
457006 | Půdorys 1.NP | 13.9 | 12 mm | 1544 | 1544 | 1556 | 1556 | 457006 | 432495 | 0.000254 | TR.03.457006 | Podlaží 1.NP | 1550 | 1550 | Podlaží 1.NP | 0 | 1545 | 1545 | 1550 | 1550 | 1555 | 1555 | Nová konstrukce | 0.00254 | Kov - Měď | 1545 | 0.000524018 | 12 | 26 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 1
457019 | Půdorys 1.NP | 1080.18 | 22 mm | 1578.4 | 2658.58 | 1578.4 | 2658.58 | 457019 | 432495 | 0.000127 | TR.03.457019 | Podlaží 1.NP | 1578.4 | 2658.58 | Podlaží 1.NP |  | 1578.4 | 2658.58 | 1578.4 | 2658.58 | 1578.4 | 2658.58 | Nová konstrukce | 0.00254 | Kov - Měď | 1578.4 | 0.0746567 | 22 | 40 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vakuum 1
457069 | Půdorys 1.NP | 26.18 | 12 mm | 1573.82 | 1600 | 1573.82 | 1600 | 457069 | 432495 | 0.000254 | TR.03.457069 | Podlaží 1.NP | 1573.82 | 1600 | Podlaží 1.NP |  | 1573.82 | 1600 | 1573.82 | 1600 | 1573.82 | 1600 | Nová konstrukce | 0.00254 | Kov - Měď | 1573.82 | 0.000986963 | 12 | 15 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 3
457083 | Půdorys 1.NP | 13.9 | 12 mm | 1544 | 1544 | 1556 | 1556 | 457083 | 432495 | 0.000254 | TR.03.457083 | Podlaží 1.NP | 1550 | 1550 | Podlaží 1.NP | 0 | 1545 | 1545 | 1550 | 1550 | 1555 | 1555 | Nová konstrukce | 0.00254 | Kov - Měď | 1545 | 0.000524018 | 12 | 15 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 3
457094 | Půdorys 1.NP | 1080.18 | 22 mm | 1578.4 | 2658.58 | 1578.4 | 2658.58 | 457094 | 432495 | 0.000127 | TR.03.457094 | Podlaží 1.NP | 1578.4 | 2658.58 | Podlaží 1.NP |  | 1578.4 | 2658.58 | 1578.4 | 2658.58 | 1578.4 | 2658.58 | Nová konstrukce | 0.00254 | Kov - Měď | 1578.4 | 0.0746567 | 22 | 22 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | Vzduch (4bar) 3
457114 | Půdorys 1.NP | 26.18 | 12 mm | 1573.82 | 1600 | 1573.82 | 1600 | 457114 | 432495 | 0.000254 | TR.03.457114 | Podlaží 1.NP | 1573.82 | 1600 | Podlaží 1.NP |  | 1573.82 | 1600 | 1573.82 | 1600 | 1573.82 | 1600 | Nová konstrukce | 0.00254 | Kov - Měď | 1573.82 | 0.000986963 | 12 | 26 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 1
457130 | Půdorys 1.NP | 13.9 | 12 mm | 1544 | 1544 | 1556 | 1556 | 457130 | 432495 | 0.000254 | TR.03.457130 | Podlaží 1.NP | 1550 | 1550 | Podlaží 1.NP | 0 | 1545 | 1545 | 1550 | 1550 | 1555 | 1555 | Nová konstrukce | 0.00254 | Kov - Měď | 1545 | 0.000524018 | 12 | 26 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 1
457141 | Půdorys 1.NP | 1080.18 | 22 mm | 1578.4 | 2658.58 | 1578.4 | 2658.58 | 457141 | 432495 | 0.000127 | TR.03.457141 | Podlaží 1.NP | 1578.4 | 2658.58 | Podlaží 1.NP |  | 1578.4 | 2658.58 | 1578.4 | 2658.58 | 1578.4 | 2658.58 | Nová konstrukce | 0.00254 | Kov - Měď | 1578.4 | 0.0746567 | 22 | 59 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 20 | Cu | O2 (4bar) 1
457693 | Půdorys 1.NP | 3478.65 | 12 mm | 2944 | 2944 | 2956 | 2956 | 457693 | 432495 | 0.000254 | TR.03.457693 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2945 | 2945 | 2950 | 2950 | 2955 | 2955 | Nová konstrukce | 0.00254 | Kov - Měď | 2945 | 0.131142 | 12 | 2 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
474520 | Půdorys 1.NP | 509.951 | 12 mm | 2944 | 2944 | 2956 | 2956 | 474520 | 432495 | 0.000254 | TR.03.474520 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2945 | 2945 | 2950 | 2950 | 2955 | 2955 | Nová konstrukce | 0.00254 | Kov - Měď | 2945 | 0.0192247 | 12 | 2 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
474534 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 474534 | 432495 | 0.000254 | TR.03.474534 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 2 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
474535 | Půdorys 1.NP | 1431.86 | 12 mm | 1494.32 | 2926.18 | 1494.32 | 2926.18 | 474535 | 432495 | 0.000254 | TR.03.474535 | Podlaží 1.NP | 2926.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2926.18 | 1494.32 | 2926.18 | 1494.32 | 2926.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0539799 | 12 | 2 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
474578 | Půdorys 1.NP | 3378.65 | 12 mm | 2944 | 2944 | 2956 | 2956 | 474578 | 432495 | 0.000254 | TR.03.474578 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2945 | 2945 | 2950 | 2950 | 2955 | 2955 | Nová konstrukce | 0.00254 | Kov - Měď | 2945 | 0.127372 | 12 | 7 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 2
474587 | Půdorys 1.NP | 659.951 | 12 mm | 2944 | 2944 | 2956 | 2956 | 474587 | 432495 | 0.000254 | TR.03.474587 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2945 | 2945 | 2950 | 2950 | 2955 | 2955 | Nová konstrukce | 0.00254 | Kov - Měď | 2945 | 0.0248796 | 12 | 7 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 2
474604 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 474604 | 432495 | 0.000254 | TR.03.474604 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 7 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 2
474605 | Půdorys 1.NP | 1431.86 | 12 mm | 1494.32 | 2926.18 | 1494.32 | 2926.18 | 474605 | 432495 | 0.000254 | TR.03.474605 | Podlaží 1.NP | 2926.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2926.18 | 1494.32 | 2926.18 | 1494.32 | 2926.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0539799 | 12 | 7 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 2
474619 | Půdorys 1.NP | 3428.65 | 12 mm | 2944 | 2944 | 2956 | 2956 | 474619 | 432495 | 0.000254 | TR.03.474619 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2945 | 2945 | 2950 | 2950 | 2955 | 2955 | Nová konstrukce | 0.00254 | Kov - Měď | 2945 | 0.129257 | 12 | 8 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 4
474651 | Půdorys 1.NP | 584.951 | 12 mm | 2944 | 2944 | 2956 | 2956 | 474651 | 432495 | 0.000254 | TR.03.474651 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2945 | 2945 | 2950 | 2950 | 2955 | 2955 | Nová konstrukce | 0.00254 | Kov - Měď | 2945 | 0.0220521 | 12 | 8 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 4
474663 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 474663 | 432495 | 0 | TR.03.474663 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 8 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 4
474664 | Půdorys 1.NP | 1431.86 | 12 mm | 1494.32 | 2926.18 | 1494.32 | 2926.18 | 474664 | 432495 | 0 | TR.03.474664 | Podlaží 1.NP | 2926.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2926.18 | 1494.32 | 2926.18 | 1494.32 | 2926.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0539799 | 12 | 8 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 4
474702 | Půdorys 1.NP | 416.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 474702 | 432495 | 0.000254 | TR.03.474702 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0157046 | 12 | 7 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 4
474716 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 474716 | 432495 | 0 | TR.03.474716 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 7 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 4
474717 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 474717 | 432495 | 0 | TR.03.474717 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 7 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 4
474761 | Půdorys 1.NP | 416.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 474761 | 432495 | 0.000254 | TR.03.474761 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0157046 | 12 | 4 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 4
474771 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 474771 | 432495 | 0 | TR.03.474771 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 4 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 4
474772 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 474772 | 432495 | 0 | TR.03.474772 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 4 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 4
474809 | Půdorys 1.NP | 416.578 | 12 mm | 3044 | 3044 | 3056 | 3056 | 474809 | 432495 | 0.000254 | TR.03.474809 | Podlaží 1.NP | 3050 | 3050 | Podlaží 1.NP | 0 | 3045 | 3045 | 3050 | 3050 | 3055 | 3055 | Nová konstrukce | 0.00254 | Kov - Měď | 3045 | 0.0157046 | 12 | 2 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 4
474821 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 474821 | 432495 | 0 | TR.03.474821 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 2 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 4
474822 | Půdorys 1.NP | 1531.86 | 12 mm | 1494.32 | 3026.18 | 1494.32 | 3026.18 | 474822 | 432495 | 0 | TR.03.474822 | Podlaží 1.NP | 3026.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 3026.18 | 1494.32 | 3026.18 | 1494.32 | 3026.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0577498 | 12 | 2 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 4
474885 | Půdorys 1.NP | 416.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 474885 | 432495 | 0.000254 | TR.03.474885 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0157046 | 12 | 10 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
474897 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 474897 | 432495 | 0 | TR.03.474897 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 10 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
474898 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 474898 | 432495 | 0 | TR.03.474898 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 10 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
474930 | Půdorys 1.NP | 416.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 474930 | 432495 | 0.000254 | TR.03.474930 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0157046 | 12 | 9 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
474940 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 474940 | 432495 | 0 | TR.03.474940 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 9 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
474941 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 474941 | 432495 | 0 | TR.03.474941 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 9 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
474973 | Půdorys 1.NP | 416.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 474973 | 432495 | 0.000254 | TR.03.474973 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0157046 | 12 | 8 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
474983 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 474983 | 432495 | 0 | TR.03.474983 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 8 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
474984 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 474984 | 432495 | 0 | TR.03.474984 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 8 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
475035 | Půdorys 1.NP | 5394.06 | 18 mm | 2941 | 2941 | 2959 | 2959 | 475035 | 432495 | 0.00015875 | TR.03.475035 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.305027 | 18 | 13 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vzduch (4bar) 2
475113 | Půdorys 1.NP | 241.998 | 12 mm | 2944 | 2944 | 2956 | 2956 | 475113 | 432495 | 0.000254 | TR.03.475113 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2945 | 2945 | 2950 | 2950 | 2955 | 2955 | Nová konstrukce | 0.00254 | Kov - Měď | 2945 | 0.00912312 | 12 | 2 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
475125 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475125 | 432495 | 0 | TR.03.475125 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 2 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
475126 | Půdorys 1.NP | 1431.86 | 12 mm | 1494.32 | 2926.18 | 1494.32 | 2926.18 | 475126 | 432495 | 0 | TR.03.475126 | Podlaží 1.NP | 2926.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2926.18 | 1494.32 | 2926.18 | 1494.32 | 2926.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0539799 | 12 | 2 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
475157 | Půdorys 1.NP | 166.998 | 12 mm | 2944 | 2944 | 2956 | 2956 | 475157 | 432495 | 0.000254 | TR.03.475157 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2945 | 2945 | 2950 | 2950 | 2955 | 2955 | Nová konstrukce | 0.00254 | Kov - Měď | 2945 | 0.00629569 | 12 | 2 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
475169 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475169 | 432495 | 0.000254 | TR.03.475169 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 2 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
475170 | Půdorys 1.NP | 1431.86 | 12 mm | 1494.32 | 2926.18 | 1494.32 | 2926.18 | 475170 | 432495 | 0.000254 | TR.03.475170 | Podlaží 1.NP | 2926.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2926.18 | 1494.32 | 2926.18 | 1494.32 | 2926.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0539799 | 12 | 2 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
475208 | Půdorys 1.NP | 316.998 | 12 mm | 2944 | 2944 | 2956 | 2956 | 475208 | 432495 | 0.000254 | TR.03.475208 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2945 | 2945 | 2950 | 2950 | 2955 | 2955 | Nová konstrukce | 0.00254 | Kov - Měď | 2945 | 0.0119506 | 12 | 2 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
475220 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475220 | 432495 | 0.000254 | TR.03.475220 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 2 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
475221 | Půdorys 1.NP | 1431.86 | 12 mm | 1494.32 | 2926.18 | 1494.32 | 2926.18 | 475221 | 432495 | 0.000254 | TR.03.475221 | Podlaží 1.NP | 2926.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2926.18 | 1494.32 | 2926.18 | 1494.32 | 2926.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0539799 | 12 | 2 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
475294 | Půdorys 1.NP | 5294.06 | 18 mm | 2941 | 2941 | 2959 | 2959 | 475294 | 432495 | 0.00015875 | TR.03.475294 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.299372 | 18 | 12 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 3
475347 | Půdorys 1.NP | 5494.06 | 18 mm | 2941 | 2941 | 2959 | 2959 | 475347 | 432495 | 0.00015875 | TR.03.475347 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.310682 | 18 | 12 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | Vakuum 4
475397 | Půdorys 1.NP | 341.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 475397 | 432495 | 0.000254 | TR.03.475397 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0128772 | 12 | 8 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
475407 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475407 | 432495 | 0.000254 | TR.03.475407 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 8 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
475408 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 475408 | 432495 | 0.000254 | TR.03.475408 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 8 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
475440 | Půdorys 1.NP | 341.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 475440 | 432495 | 0.000254 | TR.03.475440 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0128772 | 12 | 9 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
475452 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475452 | 432495 | 0.000254 | TR.03.475452 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 9 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
475453 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 475453 | 432495 | 0.000254 | TR.03.475453 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 9 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
475485 | Půdorys 1.NP | 341.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 475485 | 432495 | 0.000254 | TR.03.475485 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0128772 | 12 | 10 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
475495 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475495 | 432495 | 0.000254 | TR.03.475495 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 10 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
475496 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 475496 | 432495 | 0.000254 | TR.03.475496 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 10 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
475528 | Půdorys 1.NP | 341.578 | 12 mm | 3044 | 3044 | 3056 | 3056 | 475528 | 432495 | 0.000254 | TR.03.475528 | Podlaží 1.NP | 3050 | 3050 | Podlaží 1.NP | 0 | 3045 | 3045 | 3050 | 3050 | 3055 | 3055 | Nová konstrukce | 0.00254 | Kov - Měď | 3045 | 0.0128772 | 12 | 67 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
475540 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475540 | 432495 | 0.000254 | TR.03.475540 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 67 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
475541 | Půdorys 1.NP | 1531.86 | 12 mm | 1494.32 | 3026.18 | 1494.32 | 3026.18 | 475541 | 432495 | 0.000254 | TR.03.475541 | Podlaží 1.NP | 3026.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 3026.18 | 1494.32 | 3026.18 | 1494.32 | 3026.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0577498 | 12 | 67 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
475578 | Půdorys 1.NP | 491.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 475578 | 432495 | 0.000254 | TR.03.475578 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0185321 | 12 | 4 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 2
475592 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475592 | 432495 | 0.000254 | TR.03.475592 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 4 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 2
475593 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 475593 | 432495 | 0.000254 | TR.03.475593 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 4 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 2
475625 | Půdorys 1.NP | 491.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 475625 | 432495 | 0.000254 | TR.03.475625 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0185321 | 12 | 11 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 2
475635 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475635 | 432495 | 0.000254 | TR.03.475635 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 11 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 2
475636 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 475636 | 432495 | 0.000254 | TR.03.475636 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 11 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 2
475669 | Půdorys 1.NP | 341.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 475669 | 432495 | 0.000254 | TR.03.475669 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0128772 | 12 | 1 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
475683 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475683 | 432495 | 0.000254 | TR.03.475683 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 1 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
475684 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 475684 | 432495 | 0.000254 | TR.03.475684 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 1 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
475716 | Půdorys 1.NP | 341.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 475716 | 432495 | 0.000254 | TR.03.475716 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0128772 | 12 | 71 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
475726 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475726 | 432495 | 0.000254 | TR.03.475726 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 71 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
475727 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 475727 | 432495 | 0.000254 | TR.03.475727 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 71 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 4 (1)
475759 | Půdorys 1.NP | 491.578 | 12 mm | 3044 | 3044 | 3056 | 3056 | 475759 | 432495 | 0.000254 | TR.03.475759 | Podlaží 1.NP | 3050 | 3050 | Podlaží 1.NP | 0 | 3045 | 3045 | 3050 | 3050 | 3055 | 3055 | Nová konstrukce | 0.00254 | Kov - Měď | 3045 | 0.0185321 | 12 | 2 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 2
475769 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475769 | 432495 | 0.000254 | TR.03.475769 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 2 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 2
475770 | Půdorys 1.NP | 1531.86 | 12 mm | 1494.32 | 3026.18 | 1494.32 | 3026.18 | 475770 | 432495 | 0.000254 | TR.03.475770 | Podlaží 1.NP | 3026.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 3026.18 | 1494.32 | 3026.18 | 1494.32 | 3026.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0577498 | 12 | 2 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 2
475794 | Půdorys 1.NP | 491.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 475794 | 432495 | 0.000254 | TR.03.475794 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0185321 | 12 | 10 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
475806 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475806 | 432495 | 0.000254 | TR.03.475806 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 10 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
475807 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 475807 | 432495 | 0.000254 | TR.03.475807 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 10 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
475839 | Půdorys 1.NP | 491.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 475839 | 432495 | 0.000254 | TR.03.475839 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0185321 | 12 | 9 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
475853 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475853 | 432495 | 0.000254 | TR.03.475853 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 9 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
475854 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 475854 | 432495 | 0.000254 | TR.03.475854 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 9 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
475886 | Půdorys 1.NP | 491.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 475886 | 432495 | 0.000254 | TR.03.475886 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0185321 | 12 | 8 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
475896 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 475896 | 432495 | 0.000254 | TR.03.475896 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 8 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
475897 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 475897 | 432495 | 0.000254 | TR.03.475897 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 8 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
476256 | Půdorys 1.PP | 12771 | 28 mm | 2786 | 2786 | 2814 | 2814 | 476256 | 432495 | 0.0001016 | TR.02.476256 | Podlaží 1.NP | 2800 | 2800 | Podlaží 1.PP | 0 | 2787.5 | 2787.5 | 2800 | 2800 | 2812.5 | 2812.5 | Nová konstrukce | 0.00254 | Kov - Měď | -512.5 | 1.1234 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
476262 | Půdorys 1.PP | 12830.9 | 28 mm | 2786 | 2786 | 2814 | 2814 | 476262 | 432495 | 0.0001016 | TR.02.476262 | Podlaží 1.NP | 2800 | 2800 | Podlaží 1.PP | 0 | 2787.5 | 2787.5 | 2800 | 2800 | 2812.5 | 2812.5 | Nová konstrukce | 0.00254 | Kov - Měď | -512.5 | 1.12867 | 28 | 42 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vakuum 1
476344 | Půdorys 1.PP | 31921 | 28 mm | 2396 | 2396 | 2424 | 2424 | 476344 | 432495 | 0.0001016 | TR.02.476344 | Podlaží 1.NP | 2410 | 2410 | Podlaží 1.PP | 0 | 2397.5 | 2397.5 | 2410 | 2410 | 2422.5 | 2422.5 | Nová konstrukce | 0.00254 | Kov - Měď | -902.5 | 2.80792 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
476558 | Půdorys 1.PP | 31921 | 28 mm | 2396 | 2396 | 2424 | 2424 | 476558 | 432495 | 0.0000246602 | TR.02.476558 | Podlaží 1.NP | 2410 | 2410 | Podlaží 1.PP | 0 | 2397.5 | 2397.5 | 2410 | 2410 | 2422.5 | 2422.5 | Nová konstrukce | 0.00254 | Kov - Měď | -902.5 | 2.80792 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
476567 | Půdorys 1.PP | 1737.04 | 28 mm | 2546 | 2546 | 2574 | 2574 | 476567 | 432495 | 0.0001016 | TR.02.476567 | Podlaží 1.NP | 2560 | 2560 | Podlaží 1.PP | 0 | 2547.5 | 2547.5 | 2560 | 2560 | 2572.5 | 2572.5 | Nová konstrukce | 0.00254 | Kov - Měď | -752.5 | 0.152798 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
476578 | Půdorys 1.PP | 1252.55 | 28 mm | 2546 | 2546 | 2574 | 2574 | 476578 | 432495 | 0.0001016 | TR.02.476578 | Podlaží 1.NP | 2560 | 2560 | Podlaží 1.PP | 0 | 2547.5 | 2547.5 | 2560 | 2560 | 2572.5 | 2572.5 | Nová konstrukce | 0.00254 | Kov - Měď | -752.5 | 0.11018 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
476587 | Půdorys 1.PP | 1395.04 | 28 mm | 2546 | 2546 | 2574 | 2574 | 476587 | 432495 | 0.0001016 | TR.02.476587 | Podlaží 1.NP | 2560 | 2560 | Podlaží 1.PP | 0 | 2547.5 | 2547.5 | 2560 | 2560 | 2572.5 | 2572.5 | Nová konstrukce | 0.00254 | Kov - Měď | -752.5 | 0.122715 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
476642 | Půdorys 1.PP | 389.08 | 28 mm | 578.92 | 968 | 578.92 | 968 | 476642 | 432495 | 0.0001016 | TR.02.476642 | Podlaží 1.NP | 578.92 | 968 | Podlaží 1.PP |  | 578.92 | 968 | 578.92 | 968 | 578.92 | 968 | Nová konstrukce | 0.00254 | Kov - Měď | -2721.08 | 0.0342253 | 28 | 37 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
476653 | Půdorys 1.PP | 1737.04 | 28 mm | 2546 | 2546 | 2574 | 2574 | 476653 | 432495 | 0.0001016 | TR.02.476653 | Podlaží 1.NP | 2560 | 2560 | Podlaží 1.PP | 0 | 2547.5 | 2547.5 | 2560 | 2560 | 2572.5 | 2572.5 | Nová konstrukce | 0.00254 | Kov - Měď | -752.5 | 0.152798 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
476659 | Půdorys 1.PP | 1252.55 | 28 mm | 2546 | 2546 | 2574 | 2574 | 476659 | 432495 | 0.0001016 | TR.02.476659 | Podlaží 1.NP | 2560 | 2560 | Podlaží 1.PP | 0 | 2547.5 | 2547.5 | 2560 | 2560 | 2572.5 | 2572.5 | Nová konstrukce | 0.00254 | Kov - Měď | -752.5 | 0.11018 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
476666 | Půdorys 1.PP | 1170.04 | 28 mm | 2546 | 2546 | 2574 | 2574 | 476666 | 432495 | 0.0001016 | TR.02.476666 | Podlaží 1.NP | 2560 | 2560 | Podlaží 1.PP | 0 | 2547.5 | 2547.5 | 2560 | 2560 | 2572.5 | 2572.5 | Nová konstrukce | 0.00254 | Kov - Měď | -752.5 | 0.102922 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
476675 | Půdorys 1.PP | 101.04 | 28 mm | 2546 | 2546 | 2574 | 2574 | 476675 | 432495 | 0.0001016 | TR.02.476675 | Podlaží 1.NP | 2560 | 2560 | Podlaží 1.PP | 0 | 2547.5 | 2547.5 | 2560 | 2560 | 2572.5 | 2572.5 | Nová konstrukce | 0.00254 | Kov - Měď | -752.5 | 0.00888794 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
476757 | Půdorys 1.PP | 6968 | 28 mm | 1032 | 8000 | 1032 | 8000 | 476757 | 432495 | 0.0001016 | TR.02.476757 | Podlaží 1.NP | 8000 | 1032 | Podlaží 1.PP |  | 1032 | 8000 | 1032 | 8000 | 1032 | 8000 | Existující | 0.00254 | Kov - Měď | -2268 | 0.612937 | 28 | 23 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
476913 | Půdorys 1.PP | 25848 | 28 mm | 2936 | 2936 | 2964 | 2964 | 476913 | 432495 | 0.0001016 | TR.02.476913 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.PP | 0 | 2937.5 | 2937.5 | 2950 | 2950 | 2962.5 | 2962.5 | Nová konstrukce | 0.00254 | Kov - Měď | -362.5 | 2.27371 | 28 | 42 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vakuum 1
476971 | Půdorys 1.PP | 1405.61 | 28 mm | 2506 | 2506 | 2534 | 2534 | 476971 | 432495 | 0.0001016 | TR.02.476971 | Podlaží 1.NP | 2520 | 2520 | Podlaží 1.PP | 0 | 2507.5 | 2507.5 | 2520 | 2520 | 2532.5 | 2532.5 | Nová konstrukce | 0.00254 | Kov - Měď | -792.5 | 0.123644 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
477020 | Půdorys 1.PP | 1405.61 | 28 mm | 2506 | 2506 | 2534 | 2534 | 477020 | 432495 | 0.0001016 | TR.02.477020 | Podlaží 1.NP | 2520 | 2520 | Podlaží 1.PP | 0 | 2507.5 | 2507.5 | 2520 | 2520 | 2532.5 | 2532.5 | Nová konstrukce | 0.00254 | Kov - Měď | -792.5 | 0.123644 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
477040 | Půdorys 1.PP | 5.03817 | 28 mm | 2506 | 2506 | 2534 | 2534 | 477040 | 432495 | 0.0001016 | TR.02.477040 | Podlaží 1.NP | 2520 | 2520 | Podlaží 1.PP | 0 | 2507.5 | 2507.5 | 2520 | 2520 | 2532.5 | 2532.5 | Nová konstrukce | 0.00254 | Kov - Měď | -792.5 | 0.00044318 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
477060 | Půdorys 1.PP | 5.03817 | 28 mm | 2506 | 2506 | 2534 | 2534 | 477060 | 432495 | 0.0001016 | TR.02.477060 | Podlaží 1.NP | 2520 | 2520 | Podlaží 1.PP | 0 | 2507.5 | 2507.5 | 2520 | 2520 | 2532.5 | 2532.5 | Nová konstrukce | 0.00254 | Kov - Měď | -792.5 | 0.00044318 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
479075 | Půdorys 1.PP | 2971.27 | 12 mm | 2744 | 2744 | 2756 | 2756 | 479075 | 432495 | 0.000254 | TR.02.479075 | Podlaží 1.NP | 2750 | 2750 | Podlaží 1.PP | 0 | 2745 | 2745 | 2750 | 2750 | 2755 | 2755 | Nová konstrukce | 0.00254 | Kov - Měď | -555 | 0.112014 | 12 | 11 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
479077 | Půdorys 1.PP | 1249.2 | 12 mm | 1476.98 | 2726.18 | 1476.98 | 2726.18 | 479077 | 432495 | 0 | TR.02.479077 | Podlaží 1.NP | 1476.98 | 2726.18 | Podlaží 1.PP |  | 1476.98 | 2726.18 | 1476.98 | 2726.18 | 1476.98 | 2726.18 | Nová konstrukce | 0.00254 | Kov - Měď | -1823.02 | 0.0470937 | 12 | 11 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
479079 | Půdorys 1.PP | 2436.36 | 12 mm | 2744 | 2744 | 2756 | 2756 | 479079 | 432495 | 0.000254 | TR.02.479079 | Podlaží 1.NP | 2750 | 2750 | Podlaží 1.PP | 0 | 2745 | 2745 | 2750 | 2750 | 2755 | 2755 | Nová konstrukce | 0.00254 | Kov - Měď | -555 | 0.0918487 | 12 | 11 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
479178 | Půdorys 1.PP | 1034.36 | 12 mm | 2744 | 2744 | 2756 | 2756 | 479178 | 432495 | 0.000254 | TR.02.479178 | Podlaží 1.NP | 2750 | 2750 | Podlaží 1.PP | 0 | 2745 | 2745 | 2750 | 2750 | 2755 | 2755 | Nová konstrukce | 0.00254 | Kov - Měď | -555 | 0.0389945 | 12 | 13 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
479180 | Půdorys 1.PP | 1249.2 | 12 mm | 1476.98 | 2726.18 | 1476.98 | 2726.18 | 479180 | 432495 | 0 | TR.02.479180 | Podlaží 1.NP | 1476.98 | 2726.18 | Podlaží 1.PP |  | 1476.98 | 2726.18 | 1476.98 | 2726.18 | 1476.98 | 2726.18 | Nová konstrukce | 0.00254 | Kov - Měď | -1823.02 | 0.0470937 | 12 | 13 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
479182 | Půdorys 1.PP | 1536.36 | 12 mm | 2744 | 2744 | 2756 | 2756 | 479182 | 432495 | 0.000254 | TR.02.479182 | Podlaží 1.NP | 2750 | 2750 | Podlaží 1.PP | 0 | 2745 | 2745 | 2750 | 2750 | 2755 | 2755 | Nová konstrukce | 0.00254 | Kov - Měď | -555 | 0.0579195 | 12 | 13 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
479309 | Půdorys 1.PP | 1249.2 | 12 mm | 1476.98 | 2726.18 | 1476.98 | 2726.18 | 479309 | 432495 | 0 | TR.02.479309 | Podlaží 1.NP | 1476.98 | 2726.18 | Podlaží 1.PP |  | 1476.98 | 2726.18 | 1476.98 | 2726.18 | 1476.98 | 2726.18 | Nová konstrukce | 0.00254 | Kov - Měď | -1823.02 | 0.0470937 | 12 | 15 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
479311 | Půdorys 1.PP | 2836.36 | 12 mm | 2744 | 2744 | 2756 | 2756 | 479311 | 432495 | 0.000254 | TR.02.479311 | Podlaží 1.NP | 2750 | 2750 | Podlaží 1.PP | 0 | 2745 | 2745 | 2750 | 2750 | 2755 | 2755 | Nová konstrukce | 0.00254 | Kov - Měď | -555 | 0.106928 | 12 | 15 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
479499 | Půdorys 1.PP | 1061.47 | 28 mm | 2636 | 2636 | 2664 | 2664 | 479499 | 432495 | 0.0001016 | TR.02.479499 | Podlaží 1.NP | 2650 | 2650 | Podlaží 1.PP | 0 | 2637.5 | 2637.5 | 2650 | 2650 | 2662.5 | 2662.5 | Nová konstrukce | 0.00254 | Kov - Měď | -662.5 | 0.0933716 | 28 | 42 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vakuum 1
479582 | Půdorys 1.PP | 1136.47 | 28 mm | 2636 | 2636 | 2664 | 2664 | 479582 | 432495 | 0.0001016 | TR.02.479582 | Podlaží 1.NP | 2650 | 2650 | Podlaží 1.PP | 0 | 2637.5 | 2637.5 | 2650 | 2650 | 2662.5 | 2662.5 | Nová konstrukce | 0.00254 | Kov - Měď | -662.5 | 0.0999689 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
479618 | Půdorys 1.PP | 1211.47 | 28 mm | 2636 | 2636 | 2664 | 2664 | 479618 | 432495 | 0.0001016 | TR.02.479618 | Podlaží 1.NP | 2650 | 2650 | Podlaží 1.PP | 0 | 2637.5 | 2637.5 | 2650 | 2650 | 2662.5 | 2662.5 | Nová konstrukce | 0.00254 | Kov - Měď | -662.5 | 0.106566 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
479901 | Půdorys 1.NP | 361.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 479901 | 432495 | 0.000254 | TR.03.479901 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0136312 | 12 | 6 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
479913 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 479913 | 432495 | 0 | TR.03.479913 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 6 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
479914 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 479914 | 432495 | 0 | TR.03.479914 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 6 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 3
479947 | Půdorys 1.NP | 286.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 479947 | 432495 | 0.000254 | TR.03.479947 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.0108037 | 12 | 6 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
479959 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 479959 | 432495 | 0 | TR.03.479959 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 6 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
479960 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 479960 | 432495 | 0 | TR.03.479960 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 6 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 2
479988 | Půdorys 1.NP | 211.578 | 12 mm | 2859 | 2859 | 2871 | 2871 | 479988 | 432495 | 0.000254 | TR.03.479988 | Podlaží 1.NP | 2865 | 2865 | Podlaží 1.NP | 0 | 2860 | 2860 | 2865 | 2865 | 2870 | 2870 | Nová konstrukce | 0.00254 | Kov - Měď | 2860 | 0.00797631 | 12 | 6 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
480000 | Půdorys 1.NP | 25.3998 | 12 mm | 1464.5 | 1464.5 | 1476.5 | 1476.5 | 480000 | 432495 | 0 | TR.03.480000 | Podlaží 1.NP | 1470.5 | 1470.5 | Podlaží 1.NP | 0 | 1465.5 | 1465.5 | 1470.5 | 1470.5 | 1475.5 | 1475.5 | Nová konstrukce | 0.00254 | Kov - Měď | 1465.5 | 0.00095755 | 12 | 6 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
480001 | Půdorys 1.NP | 1346.86 | 12 mm | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 480001 | 432495 | 0 | TR.03.480001 | Podlaží 1.NP | 2841.18 | 1494.32 | Podlaží 1.NP |  | 1494.32 | 2841.18 | 1494.32 | 2841.18 | 1494.32 | 2841.18 | Nová konstrukce | 0.00254 | Kov - Měď | 1494.32 | 0.0507754 | 12 | 6 | Vakuum | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vakuum 4
480756 | Půdorys 1.PP | 19.12 | 28 mm | 986 | 986 | 1014 | 1014 | 480756 | 432495 | 0.0001016 | TR.02.480756 | Podlaží 1.NP | 1000 | 1000 | Podlaží 1.PP | 0 | 987.5 | 987.5 | 1000 | 1000 | 1012.5 | 1012.5 | Nová konstrukce | 0.00254 | Kov - Měď | -2312.5 | 0.00168188 | 28 | 41 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
480767 | Půdorys 1.PP | 6968 | 28 mm | 1032 | 8000 | 1032 | 8000 | 480767 | 432495 | 0.0001016 | TR.02.480767 | Podlaží 1.NP | 1032 | 8000 | Podlaží 1.PP |  | 1032 | 8000 | 1032 | 8000 | 1032 | 8000 | Nová konstrukce | 0.00254 | Kov - Měď | -2268 | 0.612937 | 28 | 43 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
480772 | Půdorys 1.NP | 776.02 | 28 mm | -1568 | -791.98 | -1568 | -791.98 | 480772 | 432495 | 0.0001016 | TR.02.480772 | Podlaží 1.NP | -791.98 | -1568 | Podlaží 1.NP |  | -1568 | -791.98 | -1568 | -791.98 | -1568 | -791.98 | Nová konstrukce | 0.00254 | Kov - Měď | -1568 | 0.0682623 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
480852 | Půdorys 1.NP | 176.04 | 28 mm | -754 | -754 | -726 | -726 | 480852 | 432495 | 0 | TR.02.480852 | Podlaží 1.NP | -740 | -740 | Podlaží 1.NP | 0 | -752.5 | -752.5 | -740 | -740 | -727.5 | -727.5 | Nová konstrukce | 0.00254 | Kov - Měď | -752.5 | 0.0154853 | 28 | 63 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
480938 | Půdorys 1.NP | 153.02 | 28 mm | -2248.02 | -2095 | -2248.02 | -2095 | 480938 | 432495 | 0.0001016 | TR.02.480938 | Podlaží 1.NP | -2095 | -2248.02 | Podlaží 1.NP |  | -2248.02 | -2095 | -2248.02 | -2095 | -2248.02 | -2095 | Nová konstrukce | 0.00254 | Kov - Měď | -2248.02 | 0.0134603 | 28 | 41 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
481283 | Půdorys 1.PP | 26.18 | 12 mm | 1723.82 | 1750 | 1723.82 | 1750 | 481283 | 432495 | 0.000254 | TR.02.481283 | Podlaží 1.NP | 1723.82 | 1750 | Podlaží 1.PP |  | 1723.82 | 1750 | 1723.82 | 1750 | 1723.82 | 1750 | Nová konstrukce | 0.00254 | Kov - Měď | -1576.18 | 0.000986963 | 12 | 51 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 1
481297 | Půdorys 1.PP | 5.86 | 12 mm | 1694 | 1694 | 1706 | 1706 | 481297 | 432495 | 0.000254 | TR.02.481297 | Podlaží 1.NP | 1700 | 1700 | Podlaží 1.PP | 0 | 1695 | 1695 | 1700 | 1700 | 1705 | 1705 | Nová konstrukce | 0.00254 | Kov - Měď | -1605 | 0.000220917 | 12 | 51 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 1
481321 | Půdorys 1.NP | 242 | 28 mm | -1874 | -1632 | -1874 | -1632 | 481321 | 432495 | 0.0001016 | TR.02.481321 | Podlaží 1.NP | -1632 | -1874 | Podlaží 1.NP |  | -1874 | -1632 | -1874 | -1632 | -1874 | -1632 | Nová konstrukce | 0.00254 | Kov - Měď | -1874 | 0.0212874 | 28 | 54 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
481414 | Půdorys 1.PP | 799.62 | 18 mm | 1726 | 2525.62 | 1726 | 2525.62 | 481414 | 432495 | 0.0001016 | TR.02.481414 | Podlaží 1.NP | 1726 | 2525.62 | Podlaží 1.PP |  | 1726 | 2525.62 | 1726 | 2525.62 | 1726 | 2525.62 | Nová konstrukce | 0.00254 | Kov - Měď | -1574 | 0.0452174 | 18 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 9
481418 | Půdorys 1.PP | 26.18 | 12 mm | 1723.82 | 1750 | 1723.82 | 1750 | 481418 | 432495 | 0.000254 | TR.02.481418 | Podlaží 1.NP | 1723.82 | 1750 | Podlaží 1.PP |  | 1723.82 | 1750 | 1723.82 | 1750 | 1723.82 | 1750 | Nová konstrukce | 0.00254 | Kov - Měď | -1576.18 | 0.000986963 | 12 | 51 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 9
481420 | Půdorys 1.PP | 19.26 | 12 mm | 1694 | 1694 | 1706 | 1706 | 481420 | 432495 | 0.000254 | TR.02.481420 | Podlaží 1.NP | 1700 | 1700 | Podlaží 1.PP | 0 | 1695 | 1695 | 1700 | 1700 | 1705 | 1705 | Nová konstrukce | 0.00254 | Kov - Měď | -1605 | 0.000726085 | 12 | 51 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 9
481423 | Půdorys 1.NP | 34.12 | 18 mm | -1871.62 | -1837.5 | -1871.62 | -1837.5 | 481423 | 432495 | 0.0001016 | TR.02.481423 | Podlaží 1.NP | -1871.62 | -1837.5 | Podlaží 1.NP |  | -1871.62 | -1837.5 | -1871.62 | -1837.5 | -1871.62 | -1837.5 | Nová konstrukce | 0.00254 | Kov - Měď | -1871.62 | 0.00192944 | 18 | 56 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 1
481515 | Půdorys 1.PP | 23.9 | 18 mm | 1385 | 1385 | 1403 | 1403 | 481515 | 432495 | 0.00015875 | TR.02.481515 | Podlaží 1.NP | 1394 | 1394 | Podlaží 1.PP | 0 | 1386 | 1386 | 1394 | 1394 | 1402 | 1402 | Nová konstrukce | 0.00254 | Kov - Měď | -1914 | 0.00135151 | 18 | 56 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 1
481528 | Půdorys 1.NP | 67 | 28 mm | -2005 | -1938 | -2005 | -1938 | 481528 | 432495 | 0.0001016 | TR.02.481528 | Podlaží 1.NP | -1938 | -2005 | Podlaží 1.NP |  | -2005 | -1938 | -2005 | -1938 | -2005 | -1938 | Nová konstrukce | 0.00254 | Kov - Měď | -2005 | 0.00589363 | 28 | 53 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | O2 (4bar) 1
481574 | Půdorys 1.NP | 136.5 | 18 mm | -1762.5 | -1626 | -1762.5 | -1626 | 481574 | 432495 | 0.00015875 | TR.02.481574 | Podlaží 1.NP | -1762.5 | -1626 | Podlaží 1.NP |  | -1762.5 | -1626 | -1762.5 | -1626 | -1762.5 | -1626 | Nová konstrukce | 0.00254 | Kov - Měď | -1762.5 | 0.00771889 | 18 | 52 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 9
481681 | Půdorys 1.PP | 1287.75 | 18 mm | 2551 | 2551 | 2569 | 2569 | 481681 | 432495 | 0.0001016 | TR.02.481681 | Podlaží 1.NP | 2560 | 2560 | Podlaží 1.PP | 0 | 2552 | 2552 | 2560 | 2560 | 2568 | 2568 | Nová konstrukce | 0.00254 | Kov - Měď | -748 | 0.0728203 | 18 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 9
481690 | Půdorys 1.PP | 1772.24 | 18 mm | 2551 | 2551 | 2569 | 2569 | 481690 | 432495 | 0.0001016 | TR.02.481690 | Podlaží 1.NP | 2560 | 2560 | Podlaží 1.PP | 0 | 2552 | 2552 | 2560 | 2560 | 2568 | 2568 | Nová konstrukce | 0.00254 | Kov - Měď | -748 | 0.100218 | 18 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 9
481836 | Půdorys 1.PP | 2641.73 | 18 mm | 2401 | 2401 | 2419 | 2419 | 481836 | 432495 | 0.0000246602 | TR.02.481836 | Podlaží 1.NP | 2410 | 2410 | Podlaží 1.PP | 0 | 2402 | 2402 | 2410 | 2410 | 2418 | 2418 | Nová konstrukce | 0.00254 | Kov - Měď | -898 | 0.149387 | 18 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 9
481912 | Půdorys 1.PP | 286.24 | 18 mm | 2551 | 2551 | 2569 | 2569 | 481912 | 432495 | 0.00015875 | TR.02.481912 | Podlaží 1.NP | 2560 | 2560 | Podlaží 1.PP | 0 | 2552 | 2552 | 2560 | 2560 | 2568 | 2568 | Nová konstrukce | 0.00254 | Kov - Měď | -748 | 0.0161865 | 18 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 9
481927 | Půdorys 1.PP | 1630.24 | 18 mm | 2551 | 2551 | 2569 | 2569 | 481927 | 432495 | 0.00015875 | TR.02.481927 | Podlaží 1.NP | 2560 | 2560 | Podlaží 1.PP | 0 | 2552 | 2552 | 2560 | 2560 | 2568 | 2568 | Nová konstrukce | 0.00254 | Kov - Měď | -748 | 0.0921882 | 18 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 9
482176 | Půdorys 1.PP | 138.455 | 12 mm | 2744 | 2744 | 2756 | 2756 | 482176 | 432495 | 0.000254 | TR.02.482176 | Podlaží 1.NP | 2750 | 2750 | Podlaží 1.PP | 0 | 2745 | 2745 | 2750 | 2750 | 2755 | 2755 | Nová konstrukce | 0.00254 | Kov - Měď | -555 | 0.00521965 | 12 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
482178 | Půdorys 1.PP | 1249.2 | 12 mm | 1476.98 | 2726.18 | 1476.98 | 2726.18 | 482178 | 432495 | 0 | TR.02.482178 | Podlaží 1.NP | 2726.18 | 1476.98 | Podlaží 1.PP |  | 1476.98 | 2726.18 | 1476.98 | 2726.18 | 1476.98 | 2726.18 | Nová konstrukce | 0.00254 | Kov - Měď | -1823.02 | 0.0470937 | 12 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
482182 | Půdorys 1.PP | 2020.18 | 12 mm | 2554 | 2554 | 2566 | 2566 | 482182 | 432495 | 0.000254 | TR.02.482182 | Podlaží 1.NP | 2560 | 2560 | Podlaží 1.PP | 0 | 2555 | 2555 | 2560 | 2560 | 2565 | 2565 | Nová konstrukce | 0.00254 | Kov - Měď | -745 | 0.0761588 | 12 | 30 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | O2 (4bar) 2
482352 | Půdorys 1.PP | 246.033 | 18 mm | 2401 | 2401 | 2419 | 2419 | 482352 | 432495 | 0.00015875 | TR.02.482352 | Podlaží 1.NP | 2410 | 2410 | Podlaží 1.PP | 0 | 2402 | 2402 | 2410 | 2410 | 2418 | 2418 | Nová konstrukce | 0.00254 | Kov - Měď | -898 | 0.0139128 | 18 | 27 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 2
485388 | Půdorys 1.PP | 19.12 | 28 mm | 986 | 986 | 1014 | 1014 | 485388 | 432495 | 0.0001016 | TR.02.485388 | Podlaží 1.NP | 1000 | 1000 | Podlaží 1.PP | 0 | 987.5 | 987.5 | 1000 | 1000 | 1012.5 | 1012.5 | Nová konstrukce | 0.00254 | Kov - Měď | -2312.5 | 0.00168188 | 28 | 41 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
485390 | Půdorys 1.NP | 776.02 | 28 mm | -1568 | -791.98 | -1568 | -791.98 | 485390 | 432495 | 0.0001016 | TR.02.485390 | Podlaží 1.NP | -1568 | -791.98 | Podlaží 1.NP |  | -1568 | -791.98 | -1568 | -791.98 | -1568 | -791.98 | Nová konstrukce | 0.00254 | Kov - Měď | -1568 | 0.0682623 | 28 | 21 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
485396 | Půdorys 1.NP | 153.02 | 28 mm | -2248.02 | -2095 | -2248.02 | -2095 | 485396 | 432495 | 0.0001016 | TR.02.485396 | Podlaží 1.NP | -2095 | -2248.02 | Podlaží 1.NP |  | -2248.02 | -2095 | -2248.02 | -2095 | -2248.02 | -2095 | Nová konstrukce | 0.00254 | Kov - Měď | -2248.02 | 0.0134603 | 28 | 41 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
485399 | Půdorys 1.PP | 26.18 | 12 mm | 1723.82 | 1750 | 1723.82 | 1750 | 485399 | 432495 | 0.000254 | TR.02.485399 | Podlaží 1.NP | 1723.82 | 1750 | Podlaží 1.PP |  | 1723.82 | 1750 | 1723.82 | 1750 | 1723.82 | 1750 | Nová konstrukce | 0.00254 | Kov - Měď | -1576.18 | 0.000986963 | 12 | 51 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 3
485401 | Půdorys 1.PP | 5.86 | 12 mm | 1694 | 1694 | 1706 | 1706 | 485401 | 432495 | 0.000254 | TR.02.485401 | Podlaží 1.NP | 1700 | 1700 | Podlaží 1.PP | 0 | 1695 | 1695 | 1700 | 1700 | 1705 | 1705 | Nová konstrukce | 0.00254 | Kov - Měď | -1605 | 0.000220917 | 12 | 51 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1 | 10 | Cu | Vzduch (4bar) 3
485404 | Půdorys 1.NP | 373 | 28 mm | -2005 | -1632 | -2005 | -1632 | 485404 | 432495 | 0.0001016 | TR.02.485404 | Podlaží 1.NP | -2005 | -1632 | Podlaží 1.NP |  | -2005 | -1632 | -2005 | -1632 | -2005 | -1632 | Nová konstrukce | 0.00254 | Kov - Měď | -2005 | 0.0328108 | 28 | 53 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
485451 | Půdorys 1.PP | 389.08 | 28 mm | 578.92 | 968 | 578.92 | 968 | 485451 | 432495 | 0.0001016 | TR.02.485451 | Podlaží 1.NP | 968 | 578.92 | Podlaží 1.PP |  | 578.92 | 968 | 578.92 | 968 | 578.92 | 968 | Existující | 0.00254 | Kov - Měď | -2721.08 | 0.0342253 | 28 | 18 | Vzduch | Kov - Měď - EN 13348 | EN 13348 | 1.5 | 25 | Cu | Vzduch (4bar) 3
486839 | Půdorys 1.NP | 5147.74 | 18 mm | 2941 | 2941 | 2959 | 2959 | 486839 | 432495 | 0.00015875 | TR.03.486839 | Podlaží 1.NP | 2950 | 2950 | Podlaží 1.NP | 0 | 2942 | 2942 | 2950 | 2950 | 2958 | 2958 | Nová konstrukce | 0.00254 | Kov - Měď | 2942 | 0.291098 | 18 | 1 | O2 | Kov - Měď - EN 13348 | EN 13348 | 1 | 16 | Cu | O2 (4bar) 3
